# Repository RRST-NHK-Project/kicad-ws

## KiCad design CAN hub type/CAN hub-ESC/CAN hub-ESC.kicad_pcb

Board: 2 copper layers, 10.0 x 64.0 mm, 6 parts (0 on the bottom side), 2 nets.

Parts:
ESC1, ESC2, ESC3, ESC4: CAN_BUS; JST_GH_BM02B-GHS-TBT_1x02-1MP_P1.25mm_Vertical
IN: CAN_BUS; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
OUT: CAN_BUS; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical

Connections:
CANH: ESC1.1, ESC2.1, ESC3.1, ESC4.1, IN.1, OUT.1
CANL: ESC1.2, ESC2.2, ESC3.2, ESC4.2, IN.2, OUT.2

## KiCad design XIAO/XIAO-ESP32-S3-MES/XIAO-ESP32-S3-MES.kicad_pcb

Board: 2 copper layers, 39.0 x 43.0 mm, 13 parts (0 on the bottom side), 16 nets.

Parts:
CAN1, CAN2: Conn_01x04_Socket; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
ENC1: ENC1; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
ENC2: ENC2; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
MD1: MD1; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
MD2: MD2; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R1: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: SW1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW2: SW2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW3: SW3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
TERM: R120; PinHeader_1x02_P2.54mm_Vertical
U1: DIP-8_W7.62mm
U2: XIAO-ESP32-S3-SMD

Connections:
5V0: CAN1.1, CAN2.1, ENC1.1, ENC2.1, MD1.1, MD2.1, U1.3 (Vdd), U2.14 (VBUS)
CANH: CAN1.3, CAN2.3, TERM.1, U1.7 (CANH)
CANL: CAN1.4, CAN2.4, R1.2, U1.6 (CANL)
CAN_RX: U1.4 (Rxd), U2.8 (GPIO44_D7_RX)
CAN_TX: U1.1 (Txd), U2.7 (GPIO43_D6_TX)
ENC1_A: ENC1.3, U2.5 (GPIO5_A4_D4_SDA)
ENC1_B: ENC1.4, U2.6 (GPIO6_A5_D5_SCL)
ENC2_A/SW2: ENC2.3, SW2.1, U2.9 (GPIO7_A8_D8_SCK)
ENC2_B/SW3: ENC2.4, SW3.1, U2.10 (GPIO8_A9_D9_MISO)
GND: CAN1.2, CAN2.2, ENC1.2, ENC2.2, MD1.2, MD2.2, SW1.2, SW2.2, SW3.2, U1.2 (Vss), U1.8 (STBY), U2.13 (GND)
GPIO1: MD1.3, U2.1 (GPIO1_A0_D0)
GPIO2: MD2.3, U2.2 (GPIO2_A1_D1)
GPIO3: MD1.4, U2.3 (GPIO3_A2_D2)
GPIO4: MD2.4, U2.4 (GPIO4_A3_D3)
GPIO9: SW1.1, U2.11 (GPIO9_A10_D10_MOSI)
unnamed: R1.1, TERM.2

## KiCad design CAN hub type/CAN hub 5/CAN hub 5.kicad_pcb

Parts:
CAN_BUS1, CAN_BUS2, CAN_BUS3, CAN_BUS4, CAN_BUS5: CAN_BUS; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical

Connections:
CANH: CAN_BUS1.1, CAN_BUS2.1, CAN_BUS3.1, CAN_BUS4.1, CAN_BUS5.1
CANL: CAN_BUS1.2, CAN_BUS2.2, CAN_BUS3.2, CAN_BUS4.2, CAN_BUS5.2

Board: 2 copper layers, 10.0 x 59.0 mm, 7 parts (0 on the bottom side), 2 nets.

Other parts of the board:
REF1**, REF2**: MountingHole_3.2mm_M3

## KiCad design ESP32-S3-WROOM-32E/ESP32-S3-ROS-IO-V2.0a/ESP32-S3-ROS-IO-V2.0a.kicad_pcb

Parts:
CAN_BUS1, CAN_BUS2, CAN_BUS3, CAN_BUS4: CAN_BUS; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
D1: LED; LED_D5.0mm
ENC1: ENC1; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
ENC2: ENC2; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J1, J2, J3, J4: Conn_01x22_Socket; PinSocket_1x22_P2.54mm_Vertical
J16, J17: XT60-M; AMASS_XT60-M; PARTREV V1.2
R1: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R120: R120; PinHeader_1x02_P2.54mm_Vertical
SV1: SV1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV2: SV2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV3: SV3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV4: SV4; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV5: SV5; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV6: SV6; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW1: SW1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW2: SW2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW3: SW3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW4: SW4; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW5: SW5; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
Servo1: Servo1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo2: Servo2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo3: Servo3; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo4: Servo4; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
U1: DIP-8_W7.62mm
U2: DIP-16_W7.62mm
VMD1/VMD2: VMD1/VMD2; PinHeader_1x11_P2.54mm_Vertical
VMD3/VMD4: VMD3/VMD4; PinHeader_1x11_P2.54mm_Vertical

Connections:
3V3: D1.2 (A), J1.1, J1.2, J2.1, J2.2
+24V: J17.P (POS), SV1.2, SV2.2, SV3.2, SV4.2, SV5.2, SV6.2, U2.9 (COMMON)
CANH: CAN_BUS1.1, CAN_BUS2.1, CAN_BUS3.1, CAN_BUS4.1, R1.1, R120.1, U1.7 (CANH)
CANL: CAN_BUS1.2, CAN_BUS2.2, CAN_BUS3.2, CAN_BUS4.2, R1.2, R120.2, U1.6 (CANL)
CAN_RX: J1.13, J2.13, U1.4 (Rxd)
CAN_TX: J3.5, J4.5, U1.1 (Txd)
ENC1_A: ENC1.3, J1.18, J2.18
ENC1_B: ENC1.4, J1.19, J2.19
ENC2_A: ENC2.3, J1.20, J2.20
ENC2_B: ENC2.4, J1.8, J2.8
GND: ENC1.2, ENC2.2, J1.22, J2.22, J3.1, J3.21, J3.22, J4.1, J4.21, J4.22, J16.N (NEG), J17.N (NEG), SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, Servo1.3, Servo2.3, Servo3.3, Servo4.3, U1.2 (Vss), U1.8 (STBY), U2.8 (GND), VMD1/VMD2.1, VMD1/VMD2.3, VMD3/VMD4.1, VMD3/VMD4.3
GPIO0: J3.14, J4.14, R2.2
GPIO1: J3.4, J4.4, U2.6 (I6)
GPIO4: J1.4, J2.4, VMD1/VMD2.9
GPIO5: J1.5, J2.5, VMD1/VMD2.5
GPIO6: J1.6, J2.6, VMD3/VMD4.9
GPIO7: J1.7, J2.7, VMD3/VMD4.5
GPIO8: J1.12, J2.12, VMD1/VMD2.11
GPIO9: J1.15, J2.15, VMD1/VMD2.7
GPIO10: J1.16, J2.16, VMD3/VMD4.11
GPIO11: J1.17, J2.17, VMD3/VMD4.7
GPIO16: J1.9, J2.9, Servo1.1
GPIO17: J1.10, J2.10, Servo2.1
GPIO18: J1.11, J2.11, Servo3.1
GPIO21: J3.18, J4.18, Servo4.1
GPIO35: J3.13, J4.13, SW1.1
GPIO36: J3.12, J4.12, SW2.1
GPIO37: J3.11, J4.11, SW3.1
GPIO38: J3.10, J4.10, SW4.1
GPIO39: J3.9, J4.9, SW5.1
GPIO40: J3.8, J4.8, U2.1 (I1)
GPIO41: J3.7, J4.7, U2.2 (I2)
GPIO42: J3.6, J4.6, U2.3 (I3)
GPIO47: J3.17, J4.17, U2.4 (I4)
GPIO48: J3.16, J4.16, U2.5 (I5)
NC1: J1.3, J2.3
NC2: J1.14, J2.14
NC3: J3.2, J4.2
NC4: J3.3, J4.3
NC5: J3.15, J4.15
NC6: J3.19, J4.19
NC7: J3.20, J4.20
unnamed: D1.1 (K), R2.1
O1: SV1.1, U2.16 (O1)
O2: SV2.1, U2.15 (O2)
O3: SV3.1, U2.14 (O3)
O4: SV4.1, U2.13 (O4)
O5: SV5.1, U2.12 (O5)
O6: SV6.1, U2.11 (O6)
SERVO+: J16.P (POS), Servo1.2, Servo2.2, Servo3.2, Servo4.2

Notes on the sheet:
状態表示
CAN
サーボ
VMD/MD
ソレノイドバルブ・表示灯
ピン割り当て
ESP32-S3-DevKitC用ソケット
ESP32-S3-DevKitC用ソケット(デバッグ用)
スイッチ
エンコーダ-

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
Board: 2 copper layers, 100.0 x 100.0 mm, 35 parts (0 on the bottom side), 51 nets.

## KiCad design RRST-ESP32/RRST-ESP32-S3-Rev.2-Sense/RRST-ESP32-S3-Rev.2-Sense.kicad_pcb

Parts:
C1, C4, C5: 10uF; C_0603_1608Metric
C2, C3, C6, C7, C8: 100nF; C_0603_1608Metric
C9: 1uF; C_0603_1608Metric
D1, D3, D4: LED; LED_0603_1608Metric
D2: SS14; D_SMA
D5, D6, D8: LESD5D5.0CT1G; D_SOD-523; PARTREV O
J1, J3: Conn_01x22_Pin; PinHeader_1x22_P2.54mm_Vertical
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_XKB_U262-16XN-4BVC11
J4, J6: Conn_01x04_Socket; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J7: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Vertical
R1, R2: 5.1k; R_0603_1608Metric
R3, R4: 5.1K; R_0603_1608Metric
R5: 10k; R_0603_1608Metric
R6: 330; R_0603_1608Metric
R7: 120; R_0603_1608Metric
R8: 0; R_0805_2012Metric
SW1, SW2: SW_Push; SW_SPST_TS-1088-xR020
U1: ESP32-S3-WROOM-1
U2: LD1117S33TR_SOT223; SOT-223-3_TabPin2
U4: MCP2561-E-SN; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
3V3: C3.1, C4.1, C5.1, C6.1, D1.2 (A), J1.1, J1.2, R2.1, R5.1, U1.2 (3V3), U2.2 (VO)
5V0: C1.1, C2.1, D2.1 (K), J1.21, J4.1, J6.1, J7.1, R1.1, U2.3 (VI), U4.3 (VDD)
CANH: J6.3, J7.3, R8.1, U4.7 (CANH); also elsewhere on the board
CANL: J6.4, J7.4, R7.2, U4.6 (CANL)
CAN_RX: J1.13, U1.15 (IO3), U4.4 (RXD)
CAN_TX: J3.5, U1.38 (IO2), U4.1 (TXD)
DN: D6.1, J2.A7 (D-), J2.B7 (D-), J3.20, U1.13 (USB_D-)
DP: D8.1, J2.A6 (D+), J2.B6 (D+), J3.19, U1.14 (USB_D+)
EN: C7.1, C9.1, J1.3, R5.2, SW1.2, U1.3 (EN)
ENC1_A: J1.18, J4.3, U1.20 (IO12)
ENC1_B: J1.19, J4.4, U1.21 (IO13)
ENC2_A: J1.20, U1.22 (IO14)
ENC2_B: J1.8, U1.8 (IO15)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, D3.1 (K), D4.1 (K), D5.2, D6.2, D8.2, J1.22, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J3.1, J3.21, J3.22, J4.2, J6.2, J7.2, R3.2, R4.2, SW1.1, SW2.1, U1.1 (GND), U1.40 (GND), U1.41 (GND), U2.1 (GND), U4.2 (VSS), U4.8 (STBY)
IO0: C8.1, J3.14, R6.2, SW2.2, U1.27 (IO0)
IO1: J3.4, U1.39 (IO1)
IO4: J1.4, U1.4 (IO4)
IO5: J1.5, U1.5 (IO5)
IO6: J1.6, U1.6 (IO6)
IO7: J1.7, U1.7 (IO7)
IO8: J1.12, U1.12 (IO8)
IO9: J1.15, U1.17 (IO9)
IO10: J1.16, U1.18 (IO10)
IO11: J1.17, U1.19 (IO11)
IO16: J1.9, U1.9 (IO16)
IO17: J1.10, U1.10 (IO17)
IO18: J1.11, U1.11 (IO18)
IO21: J3.18, U1.23 (IO21)
IO35: J3.13, U1.28 (IO35)
IO36: J3.12, U1.29 (IO36)
IO37: J3.11, U1.30 (IO37)
IO38: J3.10, U1.31 (IO38)
IO39: J3.9, U1.32 (IO39)
IO40: J3.8, U1.33 (IO40)
IO41: J3.7, U1.34 (IO41)
IO42: J3.6, U1.35 (IO42)
IO45: J3.15, U1.26 (IO45)
IO46: J1.14, U1.16 (IO46)
IO47: J3.17, U1.24 (IO47)
IO48: J3.16, U1.25 (IO48)
unnamed: D1.1 (K), R6.1
unnamed: D3.2 (A), R1.2
unnamed: D4.2 (A), R2.2
unnamed: J2.A5 (CC1), R4.1
unnamed: J2.B5 (CC2), R3.1
unnamed 45: R7.1, R8.2; also elsewhere on the board
RXD0: J3.3, U1.36 (RXD0)
TXD0: J3.2, U1.37 (TXD0)
VBUS: D2.2 (A), D5.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)

Notes on the sheet:
ESD保護

Board: 4 copper layers, 35 parts (2 on the bottom side), 49 nets, no tracks yet.

Other parts of the board:
TERM: 0; R_0805_2012Metric

Their connections:
CANH: TERM.1; also elsewhere on the board
unnamed 45: TERM.2; also elsewhere on the board

## KiCad design RRST-ESP32/RRST-ESP32-S3-Rev.2-Sense/GH-XH/GH-XH.kicad_pcb

Parts:
J1: Conn_01x04_Socket; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J2: Conn_01x04_Socket; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Vertical

Connections:
3V: J1.1, J2.1, J3.1
GND: J1.3, J2.3, J3.3
H1: J1.2, J2.2, J3.2
H2: J1.4, J2.4, J3.4

Board: 2 copper layers, 14.7 x 19.8 mm, 3 parts (0 on the bottom side), 4 nets.

## KiCad design CAN hub type/CAN hub 2/CAN hub 2.kicad_pcb

Parts:
CAN_BUS1, CAN_BUS2: CAN_BUS; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical

Connections:
CANH: CAN_BUS1.1, CAN_BUS2.1
CANL: CAN_BUS1.2, CAN_BUS2.2

Board: 2 copper layers, 10.0 x 34.0 mm, 4 parts (0 on the bottom side), 2 nets.

Other parts of the board:
REF1**, REF2**: MountingHole_3.2mm_M3

## KiCad design XIAO-ESP32-S3-VAR/XIAO-ESP32-S3-VAR.kicad_pcb

Board: 2 copper layers, 38.0 x 47.0 mm, 14 parts (0 on the bottom side), 15 nets.

Parts:
120: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
CAN1: CAN1; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
CAN2: CAN2; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
CANhub: CANhub; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
ENC1: ENC1; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
ENC2: ENC2; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
EXT: Conn_01x02_Pin; AMASS_XT30U-M_1x02_P5.0mm_Vertical
MCP2561: DIP-8_W7.62mm
MD1: MD1; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
SW1: SW1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
SW2: SW2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
SW3: SW3; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
TERM: R120; PinHeader_1x02_P2.54mm_Vertical
U2: XIAO-ESP32-S3-SMD

Connections:
5V0: CAN1.1, CAN2.1, ENC1.1, ENC2.1, MCP2561.3 (Vdd), MD1.1, U2.14 (VBUS)
CANH: CAN1.3, CAN2.3, CANhub.1, MCP2561.7 (CANH), TERM.1
CANL: 120.2, CAN1.4, CAN2.4, CANhub.2, MCP2561.6 (CANL)
CAN_RX: MCP2561.4 (Rxd), U2.2 (GPIO2_A1_D1)
CAN_TX: MCP2561.1 (Txd), U2.1 (GPIO1_A0_D0)
ENC1_A/MD2P: ENC1.3, U2.3 (GPIO3_A2_D2)
ENC1_B/MD2D: ENC1.4, U2.4 (GPIO4_A3_D3)
EXT_POWER: EXT.2, SW1.1, SW2.1, SW3.1
GND: CAN1.2, CAN2.2, ENC1.2, ENC2.2, EXT.1, MCP2561.2 (Vss), MCP2561.8 (STBY), MD1.2, SW1.3, SW2.3, SW3.3, U2.13 (GND)
GPIO5: ENC2.3, MD1.3, U2.5 (GPIO5_A4_D4_SDA)
GPIO6: ENC2.4, MD1.4, U2.6 (GPIO6_A5_D5_SCL)
GPIO7: SW1.2, U2.9 (GPIO7_A8_D8_SCK)
GPIO8: SW2.2, U2.10 (GPIO8_A9_D9_MISO)
GPIO9: SW3.2, U2.11 (GPIO9_A10_D10_MOSI)
unnamed: 120.1, TERM.2

## Commit log (part)

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2025-07-29 esp用の基板追加
2025-07-29 フットプリント割り当て
2025-07-29 ３Dできた
2025-07-29 3d干渉OK
2025-07-29 自動配線前のやつ
2025-07-30 完成かも
2025-07-30 １００×１００
2025-07-30 モタドラ３つバージョンの自動配線前
2025-07-30 藤澤くん頑張りました～
2025-07-30 ようやく少し進みました！！！！！！！！！！！！！！！！！！！！！！！！！！！！！！！！！！！
2025-07-31 自動配線前
2025-07-31 自動配線後
2025-07-31 PCB作りました、疲れました、寝たいです
2025-08-01 テキスト入力、自動配線し直し、穴あけ
2025-08-02 ESP割り当て
2025-08-02 100になれなかったモタドラ4枚
2025-08-03 モタドラ４つT完成 田代先輩確認お願いします
2025-08-04 配線変更
2025-08-05 PCB再設計完了!!!!
2025-08-05 基盤購入しました!!!!
2025-08-07 作り直しv2でし
2025-08-07 kakunin
2025-08-08 ESP試作ボードの追加（自動配線前）
2025-08-10 配線済み
2025-08-10 シルクの追加と修正、お盆休み開始
2025-08-12 productionに入れてます
2025-08-13 ESP用アクチュエータ基板の追加
2025-08-22 finish
2025-09-10 V1.1追加
2025-09-11 配線できたよー
2025-09-11 MOUT1,2
2025-09-11 これで完成と言うことに勝手にしておきますねむい
2025-09-11 V1.1 CADデータの追加
2025-09-11 MDの製造ファイルを出力
2025-09-12 EST32カスタムボードの追加
2025-09-12 EST32カスタムボードの修正
2025-09-12 ESP32-ROS-IO-CE-V1.0
2025-09-12 RRST-ESP32 Rev.1
2025-10-02 回路図にわかりやすくテキスト入れただけでPCB側の変更はしてないです
2025-10-02 セラコンこの大きさでいいですか？
2025-10-02 今から頑張ります
2025-10-02 授業受けます！
2025-10-02 詰め詰め
2025-10-03 配線中,,,
2025-10-03 塗りつぶしゾーンを描きたい
2025-10-03 塗りつぶしたら未配線35でした泣
2025-10-03 塗りつぶしが何も機能していなかっただけでしたが、未配線20...
2025-10-03 あと13
2025-10-03 配線完了つかれたねたい
2025-10-03 サーマルリリーフのギャップを0.1mm、スポーク幅を1.2mmにしたよー
2025-10-03 あ配線途中からてきとうにやりすぎて回路に影響がないかしんぱいです シルク印刷と塗りつぶし配線終わってエラーゼロにして、警告は50個です あとやることなんですか？？？？？？？？？？？？？？？
2025-10-04 あ-三層になっちゃった
2025-10-04 あ-四層になっちゃった
2025-10-04 製造ファイル出力、発注！たぶん大丈夫、、、たぶん、知らんけど
2025-10-20 ピンの再割り当て完了
2025-10-23 パズルタイムが始まるよー、XT横向きになったよー
2025-10-23 詰めた、配線する
2025-10-23 やりなおし
2025-10-23 がんばるんば
2025-10-23 本当の配線前
2025-10-24 配線前確認よろしくお願いします！
2025-10-24 ちぇっくかんりょう
2025-10-26 ねようみんな
2025-10-27 塗りつぶしたので確認お願いします！！
2025-10-27 XT以外のところってパッド接続実線じゃなくていいですか？
2025-10-27 一旦停止
2025-10-27 配線おねがいします
2025-10-27 配線終わりましたけど
2025-10-27 これ塗りつぶしが配線避けてくれないからそれを考慮した配線をしなくてはならなくね？ということに終了直前に気がついたのですが気のせいです。
2025-10-27 もう配線しなおし！やり直し全部！おわり！おわり、
2025-10-27 不要な塗りつぶしを削除、二層にして横向きXTにするということは基盤を大きくしてもいいということだ。
2025-10-27 ようはこういうことですよね
2025-10-27 一旦詰み
2025-10-28 無理矢理完成
2025-10-28 いや無理じゃね？
2025-10-29 一応コピーとって、配置変え開始
2025-10-29 配置変え前
2025-10-29 配置変え後
2025-10-29 一旦保存
2025-10-30 めんどくさそうな詰みそうなところの配線前
2025-10-30 これは？
2025-10-30 MDv3完成、発注に取り掛かる
2025-10-30 名前を変えただけ
2025-11-06 名前変更、整理
2025-11-06 整理整頓
2025-11-06 XT60PW-Mどっかいってもたーください
2025-11-06 綺麗になったよ☺
2025-11-06 春ロボ基板追加
2025-11-06 MD追加
2025-11-06 PCB開始
2025-11-10 外付けシリアル用の回路を追加（ピン未割り当て）
2025-11-10 シリアル変換モジュールのデータシートを追加
2025-11-10 外部シリアルにピンを割り当て
2025-11-13 Gerberをzip形式に圧縮、発注したい
2025-11-13 割り当てした
2025-11-15 XT30UPB-Mのフットプリントが入らん
2025-11-17 たすけてたしろさん
2025-11-17 COMMENT
2025-11-18 また変更したよ
2025-11-18 回路図変更
2025-11-18 やり直しだけど、XTの立体像ついかしたからなんとなくわかりやすいと思う
2025-11-18 授業中続きやるよー
2025-11-19 お姉さん基板これを元に頑張ってください
2025-11-19 発注元が空気を読んで私のミスを修正してくれますように
2025-11-20 え四方にMD乗せるってことですか？たしろさん
2025-11-20 step追加
2025-11-20 Revert "step追加"
    This reverts commit 891872a3ed6071b190a0777538c0ca4b6c1cc20c.
2025-11-20 XT30のフットプリントを追加
2025-11-20 なんでXTの位置間合わないんだ、だるい
2025-11-20 (T_T)
2025-11-21 3Dモデルがないため、オスで無理矢理ぽくする
2025-11-22 配置し直し
2025-11-22 接触しないよう変更
2025-11-22 配線前2
2025-11-25 確認お願いします
2025-12-01 配置し直し確認お願いします
2025-12-01 眠いながら頑張りました。
2025-12-01 一旦配線前満足☺
2025-12-01 手配線した☺
2025-12-01 配線済☺
2025-12-01 メイン基板完成☺
2025-12-03 ベタGND追加後発注ok
2025-12-03 シルクの修正、あとはベタGNDだけ忘れずに
2025-12-04 メイン基板かんせーーー
2025-12-04 メイン基板発注します
2025-12-08 kansei
2025-12-12 v4回路図
2025-12-12 配置途中
2025-12-12 配線のために配置変え
2025-12-12 一旦表面実装の部品探しの旅に出ます
2026-01-10 メイン基板変更進捗
2026-01-28 修正配線済みのメイン基板
2026-01-29 配線する
2026-01-29 自動配線
2026-01-29 自動配線何回目なんや
2026-01-29 自動配線そろそろさせてくれ
2026-01-30 配線途中
2026-01-31 手配線前
2026-02-05 割り当てしたい
2026-02-06 回路図変更3
2026-02-06 回路図変更4
2026-02-12 回路図確定
2026-02-12 フットプリント割り当てし直し
2026-02-12 atohaisenikko
2026-02-12 dekitayo
2026-02-12 yarinaoshi
2026-02-12 kansei?
2026-02-12 発注する
2026-02-12 回路図変更により自動配線し直し
2026-02-12 かんせー
2026-02-12 お わ り
2026-02-19 シルク入れる前
2026-02-19 製造ファイル出力
2026-02-19 シルクやり直し
2026-02-19 シルクやり直し２
2026-02-19 製造ファイル出力2
2026-02-19 製造ファイル出力3
2026-03-04 自動配線まで
2026-03-11 新MD用のESP32-S3の基板回路図
2026-03-11 旧MD用のESP32-S3の基板回路図
2026-03-11 てきとうはいち
2026-03-11 アクチュエーター数変更
2026-03-11 一応ちゃんと配置
2026-03-11 新MD配置
2026-03-11 旧MD配置決めシルク完了１
2026-03-11 旧MD配置決めシルク完了２
2026-03-13 藤井よろぴく
2026-03-15 XT30メスのフットプリントがほしい
2026-03-16 配置決め
2026-03-16 モタドラ動確取ってから考える
2026-03-18 CAN hub 2
2026-03-18 CAN hub 3
2026-03-18 CAN hub 5
2026-03-18 CAN hub
2026-03-18 製造出力
2026-03-18 表面実装にしたいがすべて互換があるわけではない
2026-03-19 フォルダ整理
2026-03-19 PHのフットプリントをどれか当てよう
2026-03-20 XIAO ESP32s3
2026-03-20 変換基板、XIAOの回路図途中
2026-03-20 回路図ほぼ確定？
2026-03-20 変換基板一応できた
2026-03-21 基板ほぼ完成
2026-03-21 変換基板ほぼかんせ
2026-03-21 基板ほぼかんせ ねむい
2026-03-22 とりあえず基板二つ完成しましたよ、あとメイン基板届いた
2026-03-22 ビア忘れてた
2026-03-24 ええんちゃうの
2026-03-24 発注すんで
2026-04-02 step出力
2026-04-30 ESPノーマルのstep
2026-05-07 output専用
2026-05-07 専用基板作るんやから良い設計が上がることを期待しています
2026-05-09 足回り専用基板
2026-05-09 can回路確認中、確認次第配線ベタグラウンド
2026-05-09 ESP32-ROS-IO-susp-V1.0
2026-05-14 ESP32-S3-Sense
2026-05-14 can回路待ち
2026-05-14 自動配線&未配線の手直し完了
2026-05-15 マイコンにセンサ入力を増設
2026-05-15 シルク修正まだ
2026-05-17 スクラップ＆ビルド
2026-05-18 仮配置完了、拡張基板設計開始
2026-05-18 拡張基板、外形線
2026-05-18 拡張基盤迷走中
2026-05-21 回路図できた
2026-05-21 PCB大体完成
2026-05-21 10かけ10に収まらない
2026-05-21 10×10に収まらないだけでそれ以外はできた
2026-05-23 どうにかする
2026-05-28 自動配線前2
2026-05-28 自動配線前3
2026-05-28 自動配線前4
2026-05-28 自動配線前desu
2026-05-28 基板完成
2026-05-29 あろはあってます。これ最新版
2026-06-04 IRLB3813
2026-06-04 IRLB3813,L7805CV,L7812CV,74HC08N,78HC14NをSMDにして回路図完成
2026-06-05 色々やってみよう
2026-06-05 とりあえず配置
2026-06-05 ちょっと変えた
2026-06-10 BLDCMD作成中...
2026-06-11 XIAO-S3の表面実装途中
2026-06-11 XIAO-S3の表面実装配置前
2026-06-11 ライブラリ用ディレクトリの作成
2026-06-11 XIAO S3の配置、配線前
2026-06-11 電源ライン配線前
2026-06-11 電源ラインの配線
2026-06-11 一晩寝かせよう
2026-06-17 製造データ出力
2026-06-18 aloha動確した？
2026-06-25 回路図２
2026-06-25 やり直し
2026-06-25 これならいけるか
2026-06-28 一旦前までのBLDCMDver.1.1提出
