# Repository RRST-NHK-Project/kicad-ws

## KiCad design CAN hub/CAN hub 2/CAN hub 2.kicad_pcb

Board: 2 copper layers, 10.0 x 34.0 mm, 4 parts (0 on the bottom side), 2 nets.

Parts:
CAN_BUS1, CAN_BUS2: CAN_BUS; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
REF1**, REF2**: MountingHole_3.2mm_M3

Connections:
CANH: CAN_BUS1.1, CAN_BUS2.1
CANL: CAN_BUS1.2, CAN_BUS2.2

## KiCad design CAN hub/CAN hub 3/CAN hub 3.kicad_pcb

Board: 2 copper layers, 10.0 x 42.0 mm, 5 parts (0 on the bottom side), 2 nets.

Parts:
CAN_BUS1, CAN_BUS2, CAN_BUS3: CAN_BUS; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
REF1**, REF2**: MountingHole_3.2mm_M3

Connections:
CANH: CAN_BUS1.1, CAN_BUS2.1, CAN_BUS3.1
CANL: CAN_BUS1.2, CAN_BUS2.2, CAN_BUS3.2

## KiCad design CAN hub/CAN hub 5/CAN hub 5.kicad_pcb

Board: 2 copper layers, 10.0 x 59.0 mm, 7 parts (0 on the bottom side), 2 nets.

Parts:
CAN_BUS1, CAN_BUS2, CAN_BUS3, CAN_BUS4, CAN_BUS5: CAN_BUS; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
REF1**, REF2**: MountingHole_3.2mm_M3

Connections:
CANH: CAN_BUS1.1, CAN_BUS2.1, CAN_BUS3.1, CAN_BUS4.1, CAN_BUS5.1
CANL: CAN_BUS1.2, CAN_BUS2.2, CAN_BUS3.2, CAN_BUS4.2, CAN_BUS5.2

## KiCad design CANMD-60/CANMD-60.kicad_pcb

File CANMD-60/README.md:

# CANMD-60 — CAN Brushed-DC Motor Driver

Single H-bridge brushed DC motor driver, CAN bus controlled, XT60 power input.
Designed as a from-scratch KiCad 10 project (schematic + PCB), generated by
script (see `scripts/`) and verified with `kicad-cli` ERC/DRC.

## Spec target
- Power in: XT60PW-M, 3S–6S LiPo (11.1–25.2 V nominal/max)
- Motor: single brushed DC, **20 A continuous, 60 A peak**
- Control: CAN bus (ISO 11898-2, 1 Mbps), daisy-chained via two JST-XH 4-pin
  connectors (GND, CANL, CANH, bus-power pass-through, not locally loaded)
- Assembly target: JLCPCB PCBA, single-side SMD + 4 TO-220 + 2 XT60 (hand/machine
  through-hole)

## Architecture
- **U5 STM32F103C8T6** — bxCAN + timers; receives CAN commands, drives the gate
  driver via PH/EN, reads current-sense feedback (PA0/ISENSE), monitors
  nFAULT/SNSOUT.
- **U4 MCP2561-H-SN** — 5 V high-speed CAN transceiver (same part already used
  elsewhere in this workspace, e.g. `ESP32-WROOM-32E/ESP32-ROS-IO-V6.0`).
- **U1 DRV8701E** — single H-bridge gate driver for 4 external N-FETs, PH/EN
  interface, integrated 20 V/V current-shunt amplifier + PWM current
  regulation, VM range 5.9–45 V (comfortable margin over 25.2 V max battery).
  All support-component values (IDRIVE, VREF divider, bulk caps) are sized
  per the DRV8701 datasheet (SLVSCX5B) design procedure, not guessed:
  - `R1` = 200 kΩ → IDRIVE 25 mA src / 50 mA sink (HS OCP monitor stays on;
    a deliberately gentler edge rate than the datasheet's small-FET example,
    since IRLB3813PBF (VDS 30 V) only has ~5 V of headroom below the 25.2 V
    rail — slower edges keep switching-induced ringing away from that limit)
  - `R4/R5` = 16 kΩ/10 kΩ off AVDD → VREF ≈ 1.85 V → current-regulation
    threshold ≈ 90 A. This is a **hardware backstop for genuine faults**
    (locked-rotor beyond spec, dead short), set above the intended 60 A peak
    on purpose so it never clips a legitimate peak; the 20 A/60 A profile
    itself is meant to be enforced in firmware from the `ISENSE` ADC reading.
  - `R7` = 1 mΩ / 3 W shunt (SP–SN/GND): 0.4 W @ 20 A continuous, 3.6 W @ 60 A
    transient — sized for the continuous figure, not the brief peak.
- **Q1–Q4 IRLB3813PBF** — TO-220 HEXFETs, reused from `MD/MDv5` in this
  workspace (same footprint library). Rds(on) 1.95 mΩ max, Qgd 19 nC — well
  inside the DRV8701's drive budget even at the gentle IDRIVE setting.
- **U2 LMR33630ADDA** — 36 V-in synchronous buck, VM → 5 V. Chosen over a
  linear regulator (unlike `MD/MDv5`'s L7805/L7812 cascade) because this
  board's load (MCU + CAN transceiver, ~150–250 mA) would dissipate ~4–5 W in
  a linear reg dropping 24 V→5 V — too hot without a heatsink. Internally
  compensated (no external RC loop to tune), fixed switching frequency, TI
  "SIMPLE SWITCHER" family — low risk without bench access.
- **U3 AMS1117-3.3** — 5 V → 3.3 V linear for MCU/logic (small drop, fine as
  linear).
- Bulk capacitance: 2×100 µF electrolytic + ceramics on VM, sized per the
  DRV8701 layout guidance ("≥10 µF minimum, more is better for high-current
  motor drive").
- Reverse-battery protection: relies on the keyed XT60 connector (matches
  this workspace's existing MD boards, which also have none) plus an SMBJ36CA
  bidirectional TVS and an ATO blade fuse (30 A, sized for 20 A continuous
  with headroom for the 60 A peak) in series with VM.

## Status

### Schematic — `CANMD-60.kicad_sch`
`kicad-cli sch erc`: **0 errors**, 71 warnings (all in the two documented-benign
classes: `lib_symbol_issues`/`footprint_link_issues` — cosmetic library-table
linking, unrelated to correctness; see `KiCAD-MCP-Server/docs/HEADLESS_AUTHORING.md`
§4 for why these are safe to ignore). Every net was cross-checked against the
intended design (VM/GND/±5V/±3.3V/PHASE_A/PHASE_B/CANH/CANL/etc. all have the
expected pin membership — see `scripts/gen_schematic.py` for the full,
explicit net table).

### PCB — `CANMD-60.kicad_pcb`
180×130 mm, 2-layer (2 oz / 70 µm copper recommended at fab time — this is an
**order option**, not something stored in the file). All 61 footprints
placed, all 72 nets assigned. Copper is a mix of:
- solid GND pour (both layers) and a VM pour over the power section,
- explicit 2.5–3 mm tracks for PHASE_A/PHASE_B/SP_N (motor + shunt current),
- explicit 0.2–0.3 mm tracks for everything else, with short thin "escape
  stubs" hand-computed for the two fine-pitch parts (U1 DRV8701 QFN-24,
  0.5 mm pitch; U5 STM32 LQFP-48, 0.5 mm pitch) so a wide power trace or a
  neighbouring signal trace doesn't graze the next pin over.

`kicad-cli pcb drc`: **0 errors in every electrical-correctness class**
(no `shorting_items`, `solder_mask_bridge`, `tracks_crossing`, or `clearance`
violations). What's left:
- **67 `unconnected_items`** (error severity, but *safe* — these are nets the
  auto-router deliberately left as an honest ratsnest line rather than force
  a track through a clearance violation; see "What to do before ordering"
  below). Concentrated ~1–4 hops per net, spread across ~35 nets — no single
  net is left mostly unrouted.
- 16 `holes_co_located` (warning) — a same-net via sitting exactly on/next to
  a same-net pad in a couple of spots; redundant copper, not a defect.
- 72 `track_dangling` (warning) — the far end of a stub/hop that IS on the
  right net but whose partner hop above is one of the 67 unrouted ones.
- 2 `silk_edge_clearance` (warning) — reference-designator text on J1/J5
  sits slightly close to the board edge; cosmetic.

### Why routing stopped here
This was generated by a hand-written greedy router (MST + pad/clearance-aware
straight-line placement — see `scripts/route.py`), not KiCad's interactive
push-and-shove router or a real autorouter. It got the design to a genuinely
safe state (zero shorts) but a hand-rolled straight-line router fundamentally
can't detour around an obstacle the way an interactive router can, so ~67
hops — mostly in the two fine-pitch ICs' immediate neighbourhood, plus a few
motor/shunt hops — were left unrouted rather than forced through a violation.

## What to do before ordering
1. Open `CANMD-60.kicad_pcb` in KiCad, **View → Ratsnest** to see the ~67
   remaining connections.
2. Route them by hand or with **Route → Interactive Router** (or run a real
   autorouter, e.g. Freerouting via the KiCad MCP server's integration —
   `docs/FREEROUTING_GUIDE.md` — now that placement and the hard nets are
   already done).
3. Re-run `kicad-cli pcb drc` and confirm 0 errors, 0 unconnected.
4. Nudge the two silkscreen-clearance warnings if you care (J1/J5 reference
   text).
5. At the JLCPCB order screen: 2-layer, **2 oz copper** (not the 1 oz
   default) given the 20 A/60 A current path, otherwise defaults are fine.

## Files
- `CANMD-60.kicad_sch` / `.kicad_pcb` / `.kicad_pro` — the KiCad project
- `CANMD-60.pretty/` — local footprints (XT60PW-M, IRLB3813PBF — reused
  verbatim from `MD/MDv5` in this workspace)
- `production/CANMD-60-gerbers.zip`, `production/gerber/CANMD-60.drl` —
  Gerbers + drill (generated from the current, not-yet-fully-routed board —
  regenerate after finishing routing)
- `production/CANMD-60-bom.csv` — BOM with LCSC part numbers filled in for
  the ICs/connectors I could verify (STM32F103C8T6, MCP2561-H/SN, DRV8701
  (PRGER/VQFN-24), IRLB3813PBF, AMS1117-3.3); generic 0603/0805/1210 passives
  are left for JLCPCB's automatic value/package matching rather than guessed
  LCSC codes.
- `production/CANMD-60-cpl.csv` — placement/CPL file (all parts on top side)
- `scripts/` — the Python generators (`gen_schematic.py`, `gen_pcb.py`,
  `route.py`, `symlib.py`, `custom_symbols.py`). Re-run
  `python3 scripts/gen_schematic.py && python3 scripts/gen_pcb.py` from this
  directory to regenerate both files from the net table in
  `scripts/gen_schematic.py` — the single source of truth for every
  connection in this design.

## Known simplifications / firmware TODOs
- `VREF` current-regulation threshold (~90 A) is a fixed resistor divider,
  not MCU-adjustable; fine as a hardware backstop, but the intended 20 A/60 A
  profile needs to be implemented in firmware via the `ISENSE` ADC channel.
- `STBY` on the CAN transceiver is hard-tied low (always active) rather than
  MCU-controlled, for simplicity.
- No MCU-side control over the CAN bus 120 Ω termination — `R12` is always
  populated; remove it if this board isn't at the physical end of the bus.
- BOOT0 is pulled low (normal boot); there's no bootloader jumper — bridge
  BOOT0 to 3V3 by hand if DFU/UART bootloader entry is ever needed.

Parts:
C1, C2: 100uF_35V; CP_Radial_D8.0mm_P3.50mm
C3, C4, C12, C13: 2.2uF_50V; C_1210_3225Metric
C5: 0.1uF; C_0603_1608Metric
C6: 10uF_50V; C_1210_3225Metric
C7: 1uF_16V; C_0805_2012Metric
C8: 0.1uF_VM; C_0805_2012Metric
C9, C10: 1uF_6V3; C_0603_1608Metric
C11: 100nF; C_0805_2012Metric
C14: 2.2nF_25V; C_0603_1608Metric
C15: 1uF_16V; C_0603_1608Metric
C16, C17: 22uF_16V; C_1210_3225Metric
C18, C19: 10uF; C_0805_2012Metric
C20, C21, C22, C24: 100nF; C_0603_1608Metric
C23: 4.7uF; C_0805_2012Metric
D1: SMBJ36CA; D_SMB
F1: 30A; FuseHolder_Blade_ATO_Littelfuse_FLR_178.6165
GND1: GND
J1, J2: XT60PW-M; AMASS_XT60PW-M
J3: CAN_IN; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J4: CAN_OUT; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J5: SWD; PinHeader_1x04_P2.54mm_Vertical
L1: 15uH_3A; L_6.3x6.3_H3
LED1: PWR; LED_0603_1608Metric
LED2: FAULT; LED_0603_1608Metric
LED3: CAN_ACT; LED_0603_1608Metric
PWR1, PWR2, PWR3: PWR_FLAG
Q1, Q2, Q3, Q4: IRLB3813PBF; PG-TO220-3_INF
R1: 200k; R_0603_1608Metric
R2, R3, R5, R6, R10, R11, R13, R14: 10k; R_0603_1608Metric
R4: 16k; R_0603_1608Metric
R7: 1mR_3W; R_2512_6332Metric
R8: 10R; R_1206_3216Metric
R9: 40.2k; R_0603_1608Metric
R12: 120R; R_0603_1608Metric
R15, R16: 1k; R_0603_1608Metric
R17: 330R; R_0603_1608Metric
U1: DRV8701E; VQFN-24-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
U2: LMR33630ADDA; Texas_HSOP-8-1EP_3.9x4.9mm_P1.27mm_ThermalVias
U3: AMS1117-3.3; SOT-223-3_TabPin2
U4: MCP2561-H-SN; SOIC-8_3.9x4.9mm_P1.27mm
U5: STM32F103C8T6; LQFP-48_7x7mm_P0.5mm

Connections:
+3V3: C19.1, C20.1, C21.1, C22.1, C23.1, J5.1, R2.1, R3.1, R6.1, R13.1, R15.1, R16.1, U3.2 (VO), U5.1 (VBAT), U5.9 (VDDA), U5.24 (VDD), U5.36 (VDD), U5.48 (VDD)
+5V: C16.1, C17.1, C18.1, L1.2, PWR3.1, R9.1, U3.3 (VI), U4.3 (VDD)
AVDD_N: C9.1, R4.1, U1.7 (AVDD)
BOOT0_N: R14.1, U5.44 (BOOT0)
BOOT_N: C14.1, U2.7 (BOOT)
BUSPWR: J3.4, J4.4
CANH: J3.3, J4.3, R12.1, U4.7 (CANH)
CANL: J3.2, J4.2, R12.2, U4.6 (CANL)
CAN_RX: U4.4 (RXD), U5.32 (PA11)
CAN_TX: U4.1 (TXD), U5.33 (PA12)
CPH_N: C8.1, U1.3 (CPH)
CPL_N: C8.2, U1.4 (CPL)
DRV_EN: U1.14 (EN), U5.16 (PA6)
DRV_PH: U1.15 (PH), U5.17 (PA7)
DVDD_N: C10.1, U1.8 (DVDD)
FB_N: R9.2, R10.1, U2.5 (FB)
GATE_H1: Q1.1 (G), U1.17 (GH1)
GATE_H2: Q3.1 (G), U1.24 (GH2)
GATE_L1: Q2.1 (G), U1.19 (GL1)
GATE_L2: Q4.1 (G), U1.22 (GL2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C9.2, C10.2, C12.2, C13.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, D1.2 (A2), GND1.1, J1.2 (-), J3.1, J4.1, J5.4, LED1.1 (K), LED3.1 (K), PWR1.1, R1.2, R5.2, R7.2, R10.2, R11.2, R14.2, U1.5 (GND), U1.16 (GND), U1.20 (SN), U1.25, U2.1 (GND), U2.9 (GND), U3.1 (GND), U4.2 (VSS), U5.8 (VSSA), U5.23 (VSS), U5.35 (VSS), U5.47 (VSS)
IDRIVE_N: R1.1, U1.12 (IDRIVE)
ISENSE: U1.11 (SO), U5.10 (PA0)
LED_CANACT: R17.1, U5.45 (PB8)
LED_CANACT_A: LED3.2 (A), R17.2
LED_FAULT_A: LED2.2 (A), R16.2
LED_PWR_A: LED1.2 (A), R15.2
NC_PA1: U5.11 (PA1)
NC_PA2: U5.12 (PA2)
NC_PA3: U5.13 (PA3)
NC_PA4: U5.14 (PA4)
NC_PA5: U5.15 (PA5)
NC_PA8: U5.29 (PA8)
NC_PA9: U5.30 (PA9)
NC_PA10: U5.31 (PA10)
NC_PA15: U5.38 (PA15)
NC_PB3: U5.39 (PB3)
NC_PB4: U5.40 (PB4)
NC_PB5: U5.41 (PB5)
NC_PB6: U5.42 (PB6)
NC_PB7: U5.43 (PB7)
NC_PB9: U5.46 (PB9)
NC_PB10: U5.21 (PB10)
NC_PB11: U5.22 (PB11)
NC_PB12: U5.25 (PB12)
NC_PB13: U5.26 (PB13)
NC_PB14: U5.27 (PB14)
NC_PB15: U5.28 (PB15)
NC_PC13: U5.2 (PC13)
NC_PC14: U5.3 (PC14)
NC_PC15: U5.4 (PC15)
NC_PD0: U5.5 (PD0)
NC_PD1: U5.6 (PD1)
NC_PG: U2.4 (PG)
NC_SPLIT: U4.5 (SPLIT)
NRST_N: C24.1, R13.2, U5.7 (NRST)
PHASE_A: J2.1 (+), Q1.3 (S), Q2.2 (D), R8.1, U1.18 (SH1)
PHASE_B: C11.2, J2.2 (-), Q3.3 (S), Q4.2 (D), U1.23 (SH2)
SNSOUT: R3.2, U1.10 (SNSOUT), U5.20 (PB2)
SNUB_N: C11.1, R8.2
SP_N: Q2.3 (S), Q4.3 (S), R7.1, U1.21 (SP)
STBY_N: R11.1, U4.8 (STBY)
SWCLK: J5.3, U5.37 (PA14)
SWDIO: J5.2, U5.34 (PA13)
SW_N: C14.2, L1.1, U2.8 (SW)
VBAT_RAW: F1.1, J1.1 (+)
VCC_N: C15.1, U2.6 (VCC)
VCP_N: C7.1, U1.2 (VCP)
VM: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, C12.1, C13.1, D1.1 (A1), F1.2, PWR2.1, Q1.2 (D), Q3.2 (D), U1.1 (VM), U2.2 (VIN), U2.3 (EN)
VREF_N: R4.2, R5.1, U1.6 (VREF)
nFAULT: LED2.1 (K), R2.2, U1.9 (nFAULT), U5.19 (PB1)
nSLEEP: R6.2, U1.13 (nSLEEP), U5.18 (PB0)

Board: 2 copper layers, 172.0 x 122.0 mm, 61 parts (0 on the bottom side), 44 nets.

File CANMD-60/production/CANMD-60-bom.csv:

Designator,Value,Footprint,Qty,LCSC Part#
"C1,C2",100uF_35V,Capacitor_THT:CP_Radial_D8.0mm_P3.50mm,2,
"C3,C4,C12,C13",2.2uF_50V,Capacitor_SMD:C_1210_3225Metric,4,
C5,0.1uF,Capacitor_SMD:C_0603_1608Metric,1,
C6,10uF_50V,Capacitor_SMD:C_1210_3225Metric,1,
C7,1uF_16V,Capacitor_SMD:C_0805_2012Metric,1,
C8,0.1uF_VM,Capacitor_SMD:C_0805_2012Metric,1,
"C9,C10",1uF_6V3,Capacitor_SMD:C_0603_1608Metric,2,
C11,100nF,Capacitor_SMD:C_0805_2012Metric,1,
C14,2.2nF_25V,Capacitor_SMD:C_0603_1608Metric,1,
C15,1uF_16V,Capacitor_SMD:C_0603_1608Metric,1,
"C16,C17",22uF_16V,Capacitor_SMD:C_1210_3225Metric,2,
"C18,C19",10uF,Capacitor_SMD:C_0805_2012Metric,2,
"C20-C22,C24",100nF,Capacitor_SMD:C_0603_1608Metric,4,
C23,4.7uF,Capacitor_SMD:C_0805_2012Metric,1,
D1,SMBJ36CA,Diode_SMD:D_SMB,1,
F1,30A,Fuse:FuseHolder_Blade_ATO_Littelfuse_FLR_178.6165,1,
"J1,J2",XT60PW-M,AMASS_XT60PW-M,2,
J3,CAN_IN,Connector_JST:JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,1,
J4,CAN_OUT,Connector_JST:JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,1,
J5,SWD,Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical,1,
L1,15uH_3A,Inductor_SMD:L_6.3x6.3_H3,1,
LED1,PWR,LED_SMD:LED_0603_1608Metric,1,
LED2,FAULT,LED_SMD:LED_0603_1608Metric,1,
LED3,CAN_ACT,LED_SMD:LED_0603_1608Metric,1,
Q1-Q4,IRLB3813PBF,PG-TO220-3_INF,4,C148140
R1,200k,Resistor_SMD:R_0603_1608Metric,1,
"R2,R3,R5,R6,R10,R11,R13,R14",10k,Resistor_SMD:R_0603_1608Metric,8,
R4,16k,Resistor_SMD:R_0603_1608Metric,1,
R7,1mR_3W,Resistor_SMD:R_2512_6332Metric,1,
R8,10R,Resistor_SMD:R_1206_3216Metric,1,
R9,40.2k,Resistor_SMD:R_0603_1608Metric,1,
R12,120R,Resistor_SMD:R_0603_1608Metric,1,
"R15,R16",1k,Resistor_SMD:R_0603_1608Metric,2,
R17,330R,Resistor_SMD:R_0603_1608Metric,1,
U1,DRV8701E,Package_DFN_QFN:VQFN-24-1EP_4x4mm_P0.5mm_EP2.5x2.5mm,1,C114178
U2,LMR33630ADDA,Package_SO:Texas_HSOP-8-1EP_3.9x4.9mm_P1.27mm_ThermalVias,1,
U3,AMS1117-3.3,Package_TO_SOT_SMD:SOT-223-3_TabPin2,1,C6186
U4,MCP2561-H-SN,Package_SO:SOIC-8_3.9x4.9mm_P1.27mm,1,C635954
U5,STM32F103C8T6,Package_QFP:LQFP-48_7x7mm_P0.5mm,1,C8734

## KiCad design ESP32-ROS-IO-V3.0/ESP32-ROS-IO-V3.0/ESP32-ROS-IO-V3.0.kicad_pcb

Parts:
CAN_BUS1, CAN_BUS2, CAN_BUS3, CAN_BUS4, CAN_BUS5, CAN_BUS6, CAN_BUS7, CAN_BUS8: CAN_BUS; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
D1: LED; LED_D5.0mm
ENC1: ENC1; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
ENC2: ENC2; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
ENC3: ENC3; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
ENC4: ENC4; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J1, J2, J3, J4: Conn_01x19_Socket; PinSocket_1x19_P2.54mm_Vertical
J5, J6: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J7: Conn_01x04_Socket; PinSocket_1x04_P2.54mm_Vertical
J8, J9, J10, J11, J12, J13, J14, J15: XT30PW-F; AMASS_XT30PW-F; PARTREV 1.2
J16, J17: XT60-M; AMASS_XT60-M; PARTREV V1.2
R1: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R120: R120; PinHeader_1x02_P2.54mm_Vertical
SV1: SV1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV2: SV2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV3: SV3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV4: SV4; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV5: SV5; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV6: SV6; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV7: SV7; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW1: SW1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW2: SW2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW3: SW3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW4: SW4; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW5: SW5; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW6: SW6; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW7, SW8: SW7; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
Servo1: Servo1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo2: Servo2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo3: Servo3; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo4: Servo4; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
U1: DIP-8_W7.62mm
U2: DIP-16_W7.62mm

Connections:
3V3: D1.2 (A), J1.1, J2.1
5V: J1.19, J2.19, J7.4, U1.3 (Vdd)
+24V: J17.P (POS), SV1.2, SV2.2, SV3.2, SV4.2, SV5.2, SV6.2, SV7.2, U2.9 (COMMON)
CANH: CAN_BUS1.1, CAN_BUS2.1, CAN_BUS3.1, CAN_BUS4.1, CAN_BUS5.1, CAN_BUS6.1, CAN_BUS7.1, CAN_BUS8.1, R120.1, U1.7 (CANH)
CANL: CAN_BUS1.2, CAN_BUS2.2, CAN_BUS3.2, CAN_BUS4.2, CAN_BUS5.2, CAN_BUS6.2, CAN_BUS7.2, CAN_BUS8.2, R1.2, U1.6 (CANL)
CAN_RX: J3.15, J4.15, U1.4 (Rxd)
CAN_TX: J3.13, J4.13, U1.1 (Txd)
GND: ENC1.2, ENC2.2, ENC3.2, ENC4.2, J1.14, J2.14, J3.1, J3.7, J4.1, J4.7, J7.3, J8.N, J8.P, J10.N, J10.P, J12.N, J12.P, J15.N, J15.P, J16.N (NEG), J17.N (NEG), SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, Servo1.3, Servo2.3, Servo3.3, Servo4.3, U1.2 (Vss), U1.8 (STBY), U2.8 (GND)
GPIO0: J3.14, J4.14, R2.2
GPIO5: J3.10, J4.10, J9.P, SW1.1
GPIO12: J1.13, J2.13, J11.P, SW2.1
GPIO13: J1.15, J2.15, J13.P, SW3.1
GPIO14: J1.12, J2.12, J7.1, J14.P, SW4.1
GPIO15: ENC3.3, J3.16, J4.16, J9.N, SW5.1
GPIO16: ENC3.4, J3.12, J4.12, J11.N, SW6.1
GPIO17: ENC4.3, J3.11, J4.11, J13.N, SW7.1
GPIO18: ENC4.4, J3.9, J4.9, J7.2, J14.N, SW8.1
GPIO19: ENC1.3, J3.8, J4.8, Servo1.1
GPIO21: ENC1.4, J3.6, J4.6, Servo2.1
GPIO22: ENC2.3, J3.3, J4.3, J5.2, Servo3.1
GPIO23: ENC2.4, J3.2, J4.2, J6.2, Servo4.1
GPIO25: J1.9, J2.9, U2.1 (I1)
GPIO26: J1.10, J2.10, U2.2 (I2)
GPIO27: J1.11, J2.11, U2.3 (I3)
GPIO32: J1.7, J2.7, U2.4 (I4)
GPIO33: J1.8, J2.8, U2.5 (I5)
NC1: J1.2, J2.2
NC2: J1.3, J2.3
NC3: J1.4, J2.4
NC4: J1.5, J2.5
NC5: J1.6, J2.6
NC6: J1.16, J2.16
NC7: J1.17, J2.17
NC8: J1.18, J2.18
NC9: J3.4, J4.4
NC10: J3.5, J4.5
NC11: J3.17, J4.17
NC12: J3.18, J4.18
NC13: J3.19, J4.19
unnamed: D1.1 (K), R2.1
unnamed: R1.1, R120.2
O1: SV1.1, U2.16 (O1)
O2: SV2.1, U2.15 (O2)
O3: SV3.1, U2.14 (O3)
O4: SV4.1, U2.13 (O4)
O5: SV5.1, U2.12 (O5)
O6: SV6.1, U2.11 (O6)
O7: SV7.1, U2.10 (O7)
SERVO+: J16.P (POS), Servo1.2, Servo2.2, Servo3.2, Servo4.2
TR6: J6.1, U2.6 (I6)
TR6_Bypass_OUT: J5.1, U2.7 (I7)
VDD33: ENC1.1, ENC2.1, ENC3.1, ENC4.1

Notes on the sheet:
バイパス用
サーボ
CAN
ピン割り当て
状態表示
ESP32-DevKitC用ソケット
VMD/MD
スイッチ
ソレノイドバルブ・表示灯
エンコーダ-
外部シリアル（MCPRINTF）
ESP32-DevKitC用ソケット(デバッグ用)

Board: 2 copper layers, 100.0 x 100.0 mm, 54 parts (0 on the bottom side), 52 nets.
