# Repository RRST-NHK-Project/kicad-ws

## KiCad design ESP32-WROOM-32E/ESP32-ROS-IO-CE-V1.0/ESP32-ROS-IO-CE-V1.0.kicad_pcb

Parts:
C1, C2: 100nF; C_01005_0402Metric
C3: 22uF/10V(20%); C_0603_1608Metric
C4, C6, C7: 0.1uF/50V(10%); C_01005_0402Metric
C5: 0.1uF/50V(10%)(NC); C_01005_0402Metric
C8, C9: 22uF/10V(20%); C_0201_0603Metric
D1, D2, D7: LED; LED_0603_1608Metric
D3, D4, D6: LESD5D5.0CT1G; D_SOD-523; PARTREV O
D5: BAT760-7; D_SOD-323; PARTREV 9-2
D8: LED; LED_D5.0mm
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_XKB_U262-16XN-4BVC11
J2, J3: XT60-M; AMASS_XT60-M_1x02_P7.20mm_Vertical; PARTREV V1.2
J4, J5: Conn_01x19_Pin; PinHeader_1x19_P2.54mm_Vertical
MD1: MD1; PinHeader_1x04_P2.54mm_Vertical
MD2: MD2; PinHeader_1x04_P2.54mm_Vertical
MD3: MD3; PinHeader_1x04_P2.54mm_Vertical
MD4: MD4; PinHeader_1x04_P2.54mm_Vertical
Q1, Q2: SS8050-G; SOT-23-3; PARTREV A; DigiKey_Part_Number 641-1790-2-ND
R1, R3: 5.1K; R_0402_1005Metric
R2, R4: 1K; R_0402_1005Metric
R5, R6, R7: 10K(5%); R_0402_1005Metric
R8: 2K(5%); R_0402_1005Metric
R9: 330; R_0402_1005Metric
SV1: SV1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV2: SV2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV3: SV3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV4: SV4; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW1: SW1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW2: SW2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW3: SW3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW4: SW4; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW9, SW10: SW_Push; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS
Servo1: Servo1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo2: Servo2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo3: Servo3; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo4: Servo4; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
U1: CH340C; JEITA_SOIC-16_3.9x9.9mm_P1.27mm
U2: DIP-16_W7.62mm
U3: ESP32-WROOM-32E
U4: AMS1117-3.3; SOT-223

Connections:
3V3: C1.1, C3.1, C6.1, C9.1, D8.2 (A), J4.1, R2.1, R4.1, R7.1, U1.4 (V3), U1.16 (VCC), U3.2 (VDD), U4.2 (VO)
5V0: C8.1, D5.C, J4.19, R8.1, U4.3 (VI)
+5V: MD1.4, MD2.4, MD3.4, MD4.4
+24V: J3.P (POS), SV1.2, SV2.2, SV3.2, SV4.2, U2.9 (COMMON)
DN: D4.1, J1.A7 (D-), J1.B7 (D-), U1.6 (UD-)
DP: D6.1, J1.A6 (D+), J1.B6 (D+), U1.5 (UD+)
DTR: C2.1, Q2.2, R5.2
EN: C4.1, C7.1, J4.2, Q1.3, R7.2, SW10.2, U3.3 (EN)
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, D3.2, D4.2, D6.2, D7.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.N (NEG), J3.N (NEG), J4.14, J5.1, J5.7, MD1.3, MD2.3, MD3.3, MD4.3, R1.2, R3.2, SW1.2, SW2.2, SW3.2, SW4.2, SW9.1, SW10.1, Servo1.3, Servo2.3, Servo3.3, Servo4.3, U1.1 (GND), U2.8 (GND), U3.1 (GND), U3.15 (GND), U3.38 (GND), U3.39 (GND), U4.1 (GND)
GPIO0: C5.1, J5.14, Q2.3, R9.2, SW9.2, U3.25 (IO0)
GPIO2: J5.15, U2.1 (I1), U3.24 (IO2)
GPIO4: J5.13, U2.2 (I2), U3.26 (IO4)
GPIO5: J5.10, U2.3 (I3), U3.29 (IO5)
GPIO12: J4.13, MD1.1, U2.4 (I4), U3.14 (IO12)
GPIO13: J4.15, MD2.1, U2.5 (I5), U3.16 (IO13)
GPIO14: J4.12, MD3.1, U2.6 (I6), U3.13 (IO14)
GPIO15: J5.16, MD4.1, U2.7 (I7), U3.23 (IO15)
GPIO16: J5.12, Servo1.1, U3.27 (IO16)
GPIO17: J5.11, Servo2.1, U3.28 (IO17)
GPIO18: J5.9, Servo3.1, U3.30 (IO18)
GPIO19: J5.8, Servo4.1, U3.31 (IO19)
GPIO21: J5.6, MD1.2, U3.33 (IO21)
GPIO22: J5.3, MD2.2, U3.36 (IO22)
GPIO23: J5.2, MD3.2, U3.37 (IO23)
GPIO25: J4.9, MD4.2, U3.10 (IO25)
GPIO26: J4.10, SW1.1, U3.11 (IO26)
GPIO27: J4.11, SW2.1, U3.12 (IO27)
GPIO32: J4.7, SW3.1, U3.8 (IO32)
GPIO33: J4.8, SW4.1, U3.9 (IO33)
IO34: J4.5, U3.6 (IO34)
IO35: J4.6, U3.7 (IO35)
NC2: J4.3, U3.4 (SENSOR_VP)
NC3: J4.4, U3.5 (SENSOR_VN)
NC9: D1.1 (K), J5.4, U1.3 (RXD), U3.35 (TXD0/IO1)
NC10: D2.1 (K), J5.5, U1.2 (TXD), U3.34 (RXD0/IO3)
unnamed: D1.2 (A), R2.2
unnamed: D2.2 (A), R4.2
unnamed: D7.2 (A), R8.2
unnamed: D8.1 (K), R9.1
unnamed: J1.A5 (CC1), R3.1
unnamed: J1.B5 (CC2), R1.1
unnamed: Q1.1, R5.1
unnamed: Q2.1, R6.1
unnamed: C2.2, U1.13 (~DTR)
O1: SV1.1, U2.16 (O1)
O2: SV2.1, U2.15 (O2)
O3: SV3.1, U2.14 (O3)
O4: SV4.1, U2.13 (O4)
O5: U2.12 (O5)
O6: U2.11 (O6)
O7: U2.10 (O7)
RTS: Q1.2, R6.2, U1.14 (~RTS)
SERVO+: J2.P (POS), Servo1.2, Servo2.2, Servo3.2, Servo4.2
VBUS: D3.1, D5.A, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)

Notes on the sheet:
コネクタ
プッシュスイッチ
通信状態表示
USB・外部電源切り替え
状態表示
書き込みモード操作
スイッチ
ESD保護
ESP32カスタムボード（ESP32 DevKitC V4 + CH340C）
サーボ
ESP32モジュール
真理値表 DTR RTS-->EN IO0 1 1 1 1 0 0 1 1 1 0 0 1 0 1 1 0
ソレノイドバルブ・表示灯
USB-UART

Board: 2 copper layers, 78.7 x 50.8 mm, 55 parts (2 on the bottom side), 51 nets.

## KiCad design ESP32-WROOM-32E/ESP32-ROS-IO-V1.0/ESP32-ROS-IO-V1.0.kicad_pcb

Parts:
J1, J2: Conn_01x19_Socket; PinSocket_1x19_P2.54mm_Vertical
J3, J4, J10, J11, J12, J14, J15, J16, J17, J18, J19: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J5, J13: XT60-M; AMASS_XT60-M_1x02_P7.20mm_Vertical; PARTREV V1.2
J6, J7, J8, J9: Conn_01x04_Pin; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
Servo1: Servo1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo2: Servo2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo3: Servo3; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo4: Servo4; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo5: Servo5; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo6: Servo6; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo7: Servo7; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo8: Servo8; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
U1: DIP-16_W7.62mm

Connections:
3V3: J1.1
5V0: J1.19
+24V: J10.2, J11.2, J12.2, J13.P (POS), J14.2, J15.2, J16.2, J17.2
GND: J1.14, J2.1, J2.7, J3.2, J4.2, J5.N (NEG), J6.2, J7.2, J8.2, J9.2, J13.N (NEG), J18.2, J19.2, Servo1.3, Servo2.3, Servo3.3, Servo4.3, Servo5.3, Servo6.3, Servo7.3, Servo8.3, U1.8 (GND); also elsewhere on the board
GPIO2: J2.15, U1.1 (I1); also elsewhere on the board
GPIO4: J2.13, U1.2 (I2); also elsewhere on the board
GPIO5: J2.10, U1.3 (I3); also elsewhere on the board
GPIO12: J1.13, J6.3, U1.4 (I4); also elsewhere on the board
GPIO13: J1.15, J6.4, U1.5 (I5); also elsewhere on the board
GPIO14: J1.12, J7.3, U1.6 (I6); also elsewhere on the board
GPIO15: J2.16, J7.4, U1.7 (I7); also elsewhere on the board
GPIO16: J2.12, Servo1.1
GPIO17: J2.11, Servo2.1
GPIO18: J2.9, Servo3.1
GPIO19: J2.8, Servo4.1
GPIO21: J2.6, J8.3, Servo5.1
GPIO22: J2.3, J8.4, Servo6.1
GPIO23: J2.2, J9.3, Servo7.1
GPIO25: J1.9, J9.4, Servo8.1
GPIO26: J1.10, J3.1
GPIO27: J1.11, J4.1
GPIO32: J1.7, J18.1
GPIO33: J1.8, J19.1
O1: J14.1, U1.16 (O1); also elsewhere on the board
O2: J15.1, U1.15 (O2); also elsewhere on the board
O3: J16.1, U1.14 (O3); also elsewhere on the board
O4: J17.1, U1.13 (O4); also elsewhere on the board
O5: J10.1, U1.12 (O5); also elsewhere on the board
O6: J11.1, U1.11 (O6); also elsewhere on the board
O7: J12.1, U1.10 (O7); also elsewhere on the board
SERVO+: J5.P (POS), Servo1.2, Servo2.2, Servo3.2, Servo4.2, Servo5.2, Servo6.2, Servo7.2, Servo8.2
VDD33: J6.1, J7.1, J8.1, J9.1

Notes on the sheet:
サーボ
ESP32-DevKitC用ソケット
スイッチ
ソレノイドバルブ・表示灯
エンコーダ

Board: 2 copper layers, 55.9 x 70.9 mm, 28 parts (2 on the bottom side), 30 nets.

Other parts of the board:
TBD62003APG: DIP-16_W7.62mm

Their connections:
GND: TBD62003APG.8 (GND); also elsewhere on the board
GPIO2: TBD62003APG.1 (I1); also elsewhere on the board
GPIO4: TBD62003APG.2 (I2); also elsewhere on the board
GPIO5: TBD62003APG.3 (I3); also elsewhere on the board
GPIO12: TBD62003APG.4 (I4); also elsewhere on the board
GPIO13: TBD62003APG.5 (I5); also elsewhere on the board
GPIO14: TBD62003APG.6 (I6); also elsewhere on the board
GPIO15: TBD62003APG.7 (I7); also elsewhere on the board
O1: TBD62003APG.16 (O1); also elsewhere on the board
O2: TBD62003APG.15 (O2); also elsewhere on the board
O3: TBD62003APG.14 (O3); also elsewhere on the board
O4: TBD62003APG.13 (O4); also elsewhere on the board
O5: TBD62003APG.12 (O5); also elsewhere on the board
O6: TBD62003APG.11 (O6); also elsewhere on the board
O7: TBD62003APG.10 (O7); also elsewhere on the board

## KiCad design ESP32-WROOM-32E/ESP32-ROS-IO-V1.1/ESP32-ROS-IO-V1.1.kicad_pcb

Parts:
CAN_BUS1, CAN_BUS2, CAN_BUS3, CAN_BUS4, CAN_BUS5, CAN_BUS6, CAN_BUS7, CAN_BUS8: CAN_BUS; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
D1: LED; LED_D5.0mm
ENC1: ENC1; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
ENC2: ENC2; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
ENC3: ENC3; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
ENC4: ENC4; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J1, J2, J3, J4: Conn_01x19_Socket; PinSocket_1x19_P2.54mm_Vertical
J12, J13: XT60-M; AMASS_XT60-M_1x02_P7.20mm_Vertical; PARTREV V1.2
MD1: MD1; PinHeader_1x04_P2.54mm_Vertical
MD2: MD2; PinHeader_1x04_P2.54mm_Vertical
MD3: MD3; PinHeader_1x04_P2.54mm_Vertical
MD4: MD4; PinHeader_1x04_P2.54mm_Vertical
MD5: MD5; PinHeader_1x04_P2.54mm_Vertical
MD6: MD6; PinHeader_1x04_P2.54mm_Vertical
MD7: MD7; PinHeader_1x04_P2.54mm_Vertical
MD8: MD8; PinHeader_1x04_P2.54mm_Vertical
R1: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R120: R120; PinHeader_1x02_P2.54mm_Vertical
SV1: SV1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV2: SV2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV3: SV3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV4: SV4; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV5: SV5; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV6: SV6; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV7: SV7; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW1: SW1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW2: SW2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW3: SW3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW4: SW4; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW5: SW5; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW6: SW6; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW7, SW8: SW7; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
Servo1: Servo1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo2: Servo2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo3: Servo3; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo4: Servo4; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo5: Servo5; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo6: Servo6; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo7: Servo7; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo8: Servo8; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
U1: DIP-8_W7.62mm
U2: DIP-16_W7.62mm
VMD1/VMD2: VMD1/VMD2; PinHeader_1x11_P2.54mm_Vertical
VMD3/VMD4: VMD3/VMD4; PinHeader_1x11_P2.54mm_Vertical

Connections:
3V3: D1.2 (A), J1.1, J2.1
5V0: J1.19, J2.19, U1.3 (Vdd)
+5V: MD1.4, MD2.4, MD3.4, MD4.4, MD5.4, MD6.4, MD7.4, MD8.4
+24V: J13.P (POS), SV1.2, SV2.2, SV3.2, SV4.2, SV5.2, SV6.2, SV7.2, U2.9 (COMMON)
CANH: CAN_BUS1.1, CAN_BUS2.1, CAN_BUS3.1, CAN_BUS4.1, CAN_BUS5.1, CAN_BUS6.1, CAN_BUS7.1, CAN_BUS8.1, R120.1, U1.7 (CANH)
CANL: CAN_BUS1.2, CAN_BUS2.2, CAN_BUS3.2, CAN_BUS4.2, CAN_BUS5.2, CAN_BUS6.2, CAN_BUS7.2, CAN_BUS8.2, R1.2, U1.6 (CANL)
GND: ENC1.2, ENC2.2, ENC3.2, ENC4.2, J1.14, J2.14, J3.1, J3.7, J4.1, J4.7, J12.N (NEG), J13.N (NEG), MD1.3, MD2.3, MD3.3, MD4.3, MD5.3, MD6.3, MD7.3, MD8.3, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, Servo1.3, Servo2.3, Servo3.3, Servo4.3, Servo5.3, Servo6.3, Servo7.3, Servo8.3, U1.2 (Vss), U1.8 (STBY), U2.8 (GND), VMD1/VMD2.1, VMD1/VMD2.3, VMD3/VMD4.1, VMD3/VMD4.3
GPIO0: J3.14, J4.14, R2.2
GPIO2: J3.15, J4.15, MD7.2, SW5.1, U2.1 (I1)
GPIO4: J3.13, J4.13, MD8.2, U1.4 (Rxd), U2.2 (I2)
GPIO5: J3.10, J4.10, MD7.1, U1.1 (Txd), U2.3 (I3)
GPIO12: ENC1.3, J1.13, J2.13, MD1.1, U2.4 (I4), VMD1/VMD2.11
GPIO13: ENC1.4, J1.15, J2.15, MD2.1, U2.5 (I5), VMD1/VMD2.7
GPIO14: ENC2.3, J1.12, J2.12, MD3.1, SW7.1, U2.6 (I6), VMD3/VMD4.11
GPIO15: ENC2.4, J3.16, J4.16, MD4.1, SW8.1, U2.7 (I7), VMD3/VMD4.7
GPIO16: J3.12, J4.12, Servo1.1
GPIO17: J3.11, J4.11, Servo2.1
GPIO18: J3.9, J4.9, Servo3.1
GPIO19: J3.8, J4.8, MD8.1, SW6.1, Servo4.1
GPIO21: ENC3.3, J3.6, J4.6, MD1.2, Servo5.1, VMD1/VMD2.9
GPIO22: ENC3.4, J3.3, J4.3, MD2.2, Servo6.1, VMD1/VMD2.5
GPIO23: ENC4.3, J3.2, J4.2, MD3.2, Servo7.1, VMD3/VMD4.9
GPIO25: ENC4.4, J1.9, J2.9, MD4.2, Servo8.1, VMD3/VMD4.5
GPIO26: J1.10, J2.10, MD5.2, SW1.1
GPIO27: J1.11, J2.11, MD6.2, SW2.1
GPIO32: J1.7, J2.7, MD5.1, SW3.1
GPIO33: J1.8, J2.8, MD6.1, SW4.1
NC1: J1.2, J2.2
NC2: J1.3, J2.3
NC3: J1.4, J2.4
NC4: J1.5, J2.5
NC5: J1.6, J2.6
NC6: J1.16, J2.16
NC7: J1.17, J2.17
NC8: J1.18, J2.18
NC9: J3.4, J4.4
NC10: J3.5, J4.5
NC11: J3.17, J4.17
NC12: J3.18, J4.18
NC13: J3.19, J4.19
unnamed: D1.1 (K), R2.1
unnamed: R1.1, R120.2
O1: SV1.1, U2.16 (O1)
O2: SV2.1, U2.15 (O2)
O3: SV3.1, U2.14 (O3)
O4: SV4.1, U2.13 (O4)
O5: SV5.1, U2.12 (O5)
O6: SV6.1, U2.11 (O6)
O7: SV7.1, U2.10 (O7)
SERVO+: J12.P (POS), Servo1.2, Servo2.2, Servo3.2, Servo4.2, Servo5.2, Servo6.2, Servo7.2, Servo8.2
VDD33: ENC1.1, ENC2.1, ENC3.1, ENC4.1

Notes on the sheet:
サーボ
CAN
状態表示
ESP32-DevKitC用ソケット
VMD/MD
スイッチ
ソレノイドバルブ・表示灯
エンコーダ-
ESP32-DevKitC用ソケット(デバッグ用)
