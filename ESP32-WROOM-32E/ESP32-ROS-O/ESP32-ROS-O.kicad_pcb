# Repository RRST-NHK-Project/kicad-ws

## KiCad design ESP32-WROOM-32E/ESP32-ROS-O/ESP32-ROS-O.kicad_pcb

Parts:
D1: LED; LED_D5.0mm
J1, J2, J3, J4: Conn_01x19_Socket; PinSocket_1x19_P2.54mm_Vertical
J16, J17: XT60-M; AMASS_XT60-M; PARTREV V1.2
R1: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SV1: SV1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV2: SV2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV3: SV3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV4: SV4; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV5: SV5; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
Servo1: Servo1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo2: Servo2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo3: Servo3; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo4: Servo4; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
U2: DIP-16_W7.62mm
VMD1/VMD2: VMD1/VMD2; PinHeader_1x11_P2.54mm_Vertical
VMD3/VMD4: VMD3/VMD4; PinHeader_1x11_P2.54mm_Vertical

Connections:
3V3: D1.2 (A), J1.1, J2.1
5V0: J1.19, J2.19
+24V: J17.P (POS), SV1.2, SV2.2, SV3.2, SV4.2, SV5.2, U2.9 (COMMON)
CAN_RX: J3.15, J4.15
CAN_TX: J3.13, J4.13
GND: J1.14, J2.14, J3.1, J3.7, J4.1, J4.7, J16.N (NEG), J17.N (NEG), Servo1.3, Servo2.3, Servo3.3, Servo4.3, U2.8 (GND), VMD1/VMD2.1, VMD1/VMD2.3, VMD3/VMD4.1, VMD3/VMD4.3
GPIO0: J3.14, J4.14, R1.2
GPIO5: J3.10, J4.10, VMD1/VMD2.9
GPIO12: J1.13, J2.13, VMD1/VMD2.5
GPIO13: J1.15, J2.15, VMD3/VMD4.9
GPIO14: J1.12, J2.12, VMD3/VMD4.5
GPIO15: J3.16, J4.16, VMD1/VMD2.11
GPIO16: J3.12, J4.12, VMD1/VMD2.7
GPIO17: J3.11, J4.11, VMD3/VMD4.11
GPIO18: J3.9, J4.9, VMD3/VMD4.7
GPIO19: J3.8, J4.8, Servo1.1
GPIO21: J3.6, J4.6, Servo2.1
GPIO22: J3.3, J4.3, Servo3.1
GPIO23: J3.2, J4.2, Servo4.1
GPIO25: J1.9, J2.9, U2.1 (I1)
GPIO26: J1.10, J2.10, U2.2 (I2)
GPIO27: J1.11, J2.11, U2.3 (I3)
GPIO32: J1.7, J2.7, U2.4 (I4)
GPIO33: J1.8, J2.8, U2.5 (I5)
NC1: J1.2, J2.2
NC2: J1.3, J2.3
NC3: J1.4, J2.4
NC4: J1.5, J2.5
NC5: J1.6, J2.6
NC6: J1.16, J2.16
NC7: J1.17, J2.17
NC8: J1.18, J2.18
NC9: J3.4, J4.4
NC10: J3.5, J4.5
NC11: J3.17, J4.17
NC12: J3.18, J4.18
NC13: J3.19, J4.19
unnamed: D1.1 (K), R1.1
O1: SV1.1, U2.16 (O1)
O2: SV2.1, U2.15 (O2)
O3: SV3.1, U2.14 (O3)
O4: SV4.1, U2.13 (O4)
O5: SV5.1, U2.12 (O5)
SERVO+: J16.P (POS), Servo1.2, Servo2.2, Servo3.2, Servo4.2

Notes on the sheet:
ソレノイドバルブ・表示灯
ESP32-DevKitC用ソケット
ESP32-DevKitC用ソケット(デバッグ用)
ピン割り当て
状態表示
VMD/MD
サーボ

Board: 2 copper layers, 20 parts (0 on the bottom side), 44 nets, no tracks yet.

## KiCad design ESP32-WROOM-32E/ESP32-S3-ROS-IO-V1.0/ESP32-S3-ROS-IO-V1.0.kicad_pcb

Board: 2 copper layers, 100.0 x 100.0 mm, 54 parts (0 on the bottom side), 57 nets.

Parts:
CAN_BUS1, CAN_BUS2, CAN_BUS3, CAN_BUS4, CAN_BUS5, CAN_BUS6, CAN_BUS7, CAN_BUS8: CAN_BUS; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
D1: LED; LED_D5.0mm
ENC1: ENC1; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
ENC2: ENC2; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
ENC3: ENC3; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
ENC4: ENC4; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J1, J2, J3, J4: Conn_01x22_Socket; PinSocket_1x22_P2.54mm_Vertical
J5, J6, J7, J8, J9: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J16, J17: XT60-M; AMASS_XT60-M
R1: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R120: R120; PinHeader_1x02_P2.54mm_Vertical
REF1**, REF2**, REF3**, REF4**: MountingHole_3.2mm_M3
SV1: SV1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV2: SV2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV3: SV3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV4: SV4; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV5: SV5; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV6: SV6; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SV7: SV7; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW1: SW1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW2: SW2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW3: SW3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW4: SW4; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW5: SW5; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW6: SW6; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW7: SW7; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW8: SW8; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
Servo1: Servo1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo2: Servo2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo3: Servo3; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Servo4: Servo4; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
U1: DIP-8_W7.62mm
U2: DIP-16_W7.62mm
VMD1/VMD2: VMD1/VMD2; PinHeader_1x11_P2.54mm_Vertical
VMD3/VMD4: VMD3/VMD4; PinHeader_1x11_P2.54mm_Vertical

Connections:
3V3: D1.2 (A), J1.1, J1.2, J2.1, J2.2
5VD: ENC1.1, ENC2.1, ENC3.1, ENC4.1, J1.21, J2.21
+24V: J17.P (POS), SV1.2, SV2.2, SV3.2, SV4.2, SV5.2, SV6.2, SV7.2, U2.9 (COMMON)
CANH: CAN_BUS1.1, CAN_BUS2.1, CAN_BUS3.1, CAN_BUS4.1, CAN_BUS5.1, CAN_BUS6.1, CAN_BUS7.1, CAN_BUS8.1, R1.1, R120.1, U1.7 (CANH)
CANL: CAN_BUS1.2, CAN_BUS2.2, CAN_BUS3.2, CAN_BUS4.2, CAN_BUS5.2, CAN_BUS6.2, CAN_BUS7.2, CAN_BUS8.2, R1.2, R120.2, U1.6 (CANL)
CAN_RX: J1.13, J2.13, U1.4 (Rxd)
CAN_TX: J3.5, J4.5, U1.1 (Txd)
ENC1_A: ENC1.3, J1.18, J2.18
ENC1_B: ENC1.4, J1.19, J2.19
ENC2_A: ENC2.3, J1.20, J2.20
ENC2_B: ENC2.4, J1.8, J2.8
ENC3_A: ENC3.3, J1.9, J2.9
ENC3_B: ENC3.4, J1.10, J2.10
ENC4_A: ENC4.3, J1.11, J2.11
ENC4_B: ENC4.4, J3.18, J4.18
GND: ENC1.2, ENC2.2, ENC3.2, ENC4.2, J1.22, J2.22, J3.1, J3.21, J3.22, J4.1, J4.21, J4.22, J16.N (NEG), J17.N (NEG), SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, Servo1.3, Servo2.3, Servo3.3, Servo4.3, U1.2 (Vss), U1.8 (STBY), U2.8 (GND), VMD1/VMD2.1, VMD1/VMD2.3, VMD3/VMD4.1, VMD3/VMD4.3
GPIO0: J3.14, J4.14, R2.2
GPIO1: J3.4, J4.4, J9.2
GPIO4: J1.4, J2.4, VMD1/VMD2.9
GPIO5: J1.5, J2.5, VMD1/VMD2.5
GPIO6: J1.6, J2.6, VMD3/VMD4.9
GPIO7: J1.7, J2.7, VMD3/VMD4.5
GPIO8: J1.12, J2.12, VMD1/VMD2.11
GPIO9: J1.15, J2.15, VMD1/VMD2.7
GPIO10: J1.16, J2.16, VMD3/VMD4.11
GPIO11: J1.17, J2.17, VMD3/VMD4.7
GPIO35: J3.13, J4.13, Servo1.1
GPIO36: J3.12, J4.12, SW8.1, Servo2.1
GPIO37: J3.11, J4.11, SW7.1, Servo3.1
GPIO38: J3.10, J4.10, SW6.1, Servo4.1
GPIO39: J3.9, J4.9, U2.1 (I1)
GPIO40: J3.8, J4.8, U2.2 (I2)
GPIO41: J3.7, J4.7, J5.2
GPIO42: J3.6, J4.6, J6.2
GPIO47: J3.17, J4.17, J7.2
GPIO48: J3.16, J4.16, J8.2
NC1: J1.3, J2.3
NC2: J1.14, J2.14
NC3: J3.2, J4.2
NC4: J3.3, J4.3
NC5: J3.15, J4.15
NC6: J3.19, J4.19
NC7: J3.20, J4.20
unnamed: D1.1 (K), R2.1
O1: SV1.1, U2.16 (O1)
O2: SV2.1, U2.15 (O2)
O3: SV3.1, U2.14 (O3)
O4: SV4.1, U2.13 (O4)
O5: SV5.1, U2.12 (O5)
O6: SV6.1, U2.11 (O6)
O7: SV7.1, U2.10 (O7)
SERVO+: J16.P (POS), Servo1.2, Servo2.2, Servo3.2, Servo4.2
TR3_Bypass_OUT: J5.1, SW5.1, U2.3 (I3)
TR4_Bypass_OUT: J6.1, SW4.1, U2.4 (I4)
TR5_Bypass_OUT: J7.1, SW3.1, U2.5 (I5)
TR6_Bypass_OUT: J8.1, SW2.1, U2.6 (I6)
TR7_Bypass_OUT: J9.1, SW1.1, U2.7 (I7)

## KiCad design ESP32-WROOM-32E/ESP32-WROOM-32E-RRST-beta/ESP32-WROOM-32E-RRST-beta.kicad_pcb

Board: 2 copper layers, 30.5 x 50.8 mm, 34 parts (2 on the bottom side), 43 nets.

Parts:
C3: 22uF/10V(20%); C_0603_1608Metric
C4, C6, C7: 0.1uF/50V(10%); C_01005_0402Metric
C5: 0.1uF/50V(10%)(NC); C_01005_0402Metric
C8, C9: 22uF/10V(20%); C_0201_0603Metric
C10, C11: 100nF; C_01005_0402Metric
D1, D2, D4: LESD5D5.0CT1G; D_SOD-523
D3: BAT760-7; D_SOD-323
D5, D6, D7: LED; LED_0603_1608Metric
J1, J3: Conn_01x19_Pin; PinHeader_1x19_P2.54mm_Vertical
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_XKB_U262-16XN-4BVC11
Q1, Q2: SS8050-G; SOT-23-3
R1, R2: 1K; R_0402_1005Metric
R3, R4: 5.1K; R_0402_1005Metric
R5, R6, R17: 10K(5%); R_0402_1005Metric
R18: 2K(5%); R_0402_1005Metric
SW1, SW2: SW_Push; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS
U1: CH340C; JEITA_SOIC-16_3.9x9.9mm_P1.27mm
U10: ESP32-WROOM-32E
U11: AMS1117-3.3; SOT-223

Connections:
DN: D2.1, J2.A7 (D-), J2.B7 (D-), U1.6 (UD-)
DP: D4.1, J2.A6 (D+), J2.B6 (D+), U1.5 (UD+)
DTR: C11.1, Q2.2, R5.2
EN: C4.1, C7.1, J1.2, Q1.3, R17.2, SW2.2, U10.3 (EN)
EXT_5V: C8.1, D3.C, J1.19, R18.1, U11.3 (VI)
GND: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, D1.2, D2.2, D4.2, D5.1 (K), J1.14, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J3.1, J3.7, R3.2, R4.2, SW1.1, SW2.1, U1.1 (GND), U10.1 (GND), U10.15 (GND), U10.38 (GND), U10.39 (GND), U11.1 (GND)
IO0: C5.1, J3.14, Q2.3, SW1.2, U10.25 (IO0)
IO2: J3.15, U10.24 (IO2)
IO4: J3.13, U10.26 (IO4)
IO5: J3.10, U10.29 (IO5)
IO12: J1.13, U10.14 (IO12)
IO13: J1.15, U10.16 (IO13)
IO14: J1.12, U10.13 (IO14)
IO15: J3.16, U10.23 (IO15)
IO16: J3.12, U10.27 (IO16)
IO17: J3.11, U10.28 (IO17)
IO18: J3.9, U10.30 (IO18)
IO19: J3.8, U10.31 (IO19)
IO21: J3.6, U10.33 (IO21)
IO22: J3.3, U10.36 (IO22)
IO23: J3.2, U10.37 (IO23)
IO25: J1.9, U10.10 (IO25)
IO26: J1.10, U10.11 (IO26)
IO27: J1.11, U10.12 (IO27)
IO32: J1.7, U10.8 (IO32)
IO33: J1.8, U10.9 (IO33)
IO34: J1.5, U10.6 (IO34)
IO35: J1.6, U10.7 (IO35)
unnamed: D5.2 (A), R18.2
unnamed: D6.2 (A), R1.2
unnamed: D7.2 (A), R2.2
unnamed: J2.A5 (CC1), R4.1
unnamed: J2.B5 (CC2), R3.1
unnamed: Q1.1, R5.1
unnamed: Q2.1, R6.1
unnamed: C11.2, U1.13 (~DTR)
RTS: Q1.2, R6.2, U1.14 (~RTS)
RX: D6.1 (K), J3.4, U1.3 (RXD), U10.35 (TXD0/IO1)
RXD0/IO3: D7.1 (K), J3.5, U1.2 (TXD), U10.34 (RXD0/IO3)
SENSOR_VN: J1.4, U10.5 (SENSOR_VN)
SENSOR_VP: J1.3, U10.4 (SENSOR_VP)
VBUS: D1.1, D3.A, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
VDD33: C3.1, C6.1, C9.1, C10.1, J1.1, R1.1, R2.1, R17.1, U1.4 (V3), U1.16 (VCC), U10.2 (VDD), U11.2 (VO)

## KiCad design ESP32-WROOM-32E/ESP32-WROOM-32E-RRST/ESP32-WROOM-32E-RRST.kicad_pcb

Parts:
C1: 10uF/10V(20%); C_0805_2012Metric
C2, C4, C6, C7: 0.1uF/50V(10%); C_0805_2012Metric
C3, C8, C9: 22uF/10V(20%); C_0805_2012Metric
C5: 0.1uF/50V(10%)(NC); C_0805_2012Metric
C10: 0.1uF; C_0805_2012Metric
D1, D2, D4: LESD5D5.0CT1G; D_SOD-523; PARTREV O
D3: BAT760-7; D_SOD-323; PARTREV 9-2
D5: LED; LED_0805_2012Metric
J1: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J2, J3, J13, J18, J19, J20: XT60-M; AMASS_XT60-M_1x02_P7.20mm_Vertical; PARTREV V1.2
J4, J5: Conn_01x11_Pin; PinHeader_1x11_P2.54mm_Vertical
J6, J7, J8, J9: Conn_01x04_Pin; JST_XH_B4B-XH-AM_1x04_P2.50mm_Vertical
J10, J11, J12, J14, J15, J16, J17, J22, J23, J24, J25: Conn_01x02_Pin; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
J21: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
Q1, Q2: SS8050-G; TSOT-23; PARTREV A; DigiKey_Part_Number 641-1790-2-ND
R1: 120; R_0805_2012Metric
R5, R6, R17: 10K(5%); R_0805_2012Metric
R7, R8: 0R; R_0805_2012Metric
R13: 22.1K(1%); R_0805_2012Metric
R14: 47.5K(1%); R_0805_2012Metric
R15, R18: 2K(5%); R_0805_2012Metric
R16: 10K(5%)(NC); R_0805_2012Metric
SW1, SW2: SW_Push; SW_Push_SPST_NO_Alps_SKRK
Servo1: Servo1; JST_XH_B3B-XH-AM_1x03_P2.50mm_Vertical
Servo2: Servo2; JST_XH_B3B-XH-AM_1x03_P2.50mm_Vertical
Servo3: Servo3; JST_XH_B3B-XH-AM_1x03_P2.50mm_Vertical
Servo4: Servo4; JST_XH_B3B-XH-AM_1x03_P2.50mm_Vertical
Servo5: Servo5; JST_XH_B3B-XH-AM_1x03_P2.50mm_Vertical
Servo6: Servo6; JST_XH_B3B-XH-AM_1x03_P2.50mm_Vertical
Servo7: Servo7; JST_XH_B3B-XH-AM_1x03_P2.50mm_Vertical
Servo8: Servo8; JST_XH_B3B-XH-AM_1x03_P2.50mm_Vertical
U1: DIP-16_W7.62mm
U2: MCP2562-E-P; DIP-8_W7.62mm
U9: CP2102N-A02-GQFN28; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm
U10: ESP32-WROOM-32E; ESP32-WROOM-32D
U11: AMS1117-3.3; SOT-223-3_TabPin2
VMD1/VMD2: VMD1/VMD2; PinHeader_1x11_P2.54mm_Vertical
VMD3/VMD4: VMD3/VMD4; PinHeader_1x11_P2.54mm_Vertical
VMD5/VMD6: VMD5/VMD6; PinHeader_1x11_P2.54mm_Vertical
VMD7/VMD8: VMD7/VMD8; PinHeader_1x11_P2.54mm_Vertical

Connections:
5V: C8.1, D3.C, R18.1, U2.3 (VDD), U11.3 (VI)
+24V: J2.P (POS), J10.2, J11.2, J12.2, J13.P (POS), J14.2, J15.2, J16.2, J17.2, J18.P (POS), J19.P (POS), J20.P (POS)
CANH: J21.2, J22.2, J23.2, J24.2, J25.2, U2.7 (CANH)
CANL: J22.1, J23.1, J24.1, J25.1, R1.2, U2.6 (CANL)
CTS: U9.23 (~CTS)
DCD: U9.1 (~DCD)
DSR: U9.27 (~DSR)
DTR: Q2.3, R5.2, U9.28 (~DTR)
EN: C4.1, C7.1, Q1.3, R17.2, SW2.2, U10.3 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, D1.2, D2.2, D4.2, D5.1 (K), J1.5 (GND), J1.6 (Shield), J2.N (NEG), J3.N (NEG), J5.10, J5.11, J6.2, J7.2, J8.2, J9.2, J13.N (NEG), J18.N (NEG), J19.N (NEG), J20.N (NEG), R14.2, R16.2, SW1.1, SW2.1, Servo1.3, Servo2.3, Servo3.3, Servo4.3, Servo5.3, Servo6.3, Servo7.3, Servo8.3, U1.8 (GND), U2.2 (VSS), U2.8 (STBY), U10.1 (GND), U10.15 (GND), U10.38 (GND), U10.39 (GND), U11.1 (GND), VMD1/VMD2.1, VMD1/VMD2.3, VMD3/VMD4.1, VMD3/VMD4.3, VMD5/VMD6.1, VMD5/VMD6.3, VMD7/VMD8.1, VMD7/VMD8.3
IO0: C5.1, Q2.2, SW1.2
IO2: J4.1, J6.3, U10.24 (IO2), VMD1/VMD2.5
IO4: J4.2, U2.4 (RXD), U10.26 (IO4)
IO5: J4.3, U2.1 (TXD), U10.29 (IO5)
IO12: J4.4, J6.4, U10.14 (IO12), VMD1/VMD2.7
IO13: J4.5, J7.3, U10.16 (IO13), VMD1/VMD2.9
IO14: J4.6, J7.4, U10.13 (IO14), VMD1/VMD2.11
IO15: J4.7, J8.3, U10.23 (IO15), VMD3/VMD4.5
IO16: J4.8, J8.4, U10.27 (IO16), VMD3/VMD4.7
IO17: J4.9, J9.3, U10.28 (IO17), VMD3/VMD4.9
IO18: J4.10, J9.4, U10.30 (IO18), VMD3/VMD4.11
IO19: J4.11, Servo1.1, U10.31 (IO19), VMD5/VMD6.5
IO21: J5.1, Servo2.1, U10.33 (IO21), VMD5/VMD6.7
IO22: J5.2, Servo3.1, U1.6 (I6), U10.36 (IO22), VMD5/VMD6.9
IO23: J5.3, Servo4.1, U1.7 (I7), U10.37 (IO23), VMD5/VMD6.11
IO25: J5.4, Servo5.1, U1.1 (I1), U10.10 (IO25), VMD7/VMD8.5
IO26: J5.5, Servo6.1, U1.2 (I2), U10.11 (IO26), VMD7/VMD8.7
IO27: J5.6, Servo7.1, U1.3 (I3), U10.12 (IO27), VMD7/VMD8.9
IO32: J5.7, Servo8.1, U1.4 (I4), U10.8 (IO32), VMD7/VMD8.11
IO33: J5.8, U1.5 (I5), U10.9 (IO33)
unnamed: D5.2 (A), R18.2
unnamed: J21.1, R1.1
unnamed: Q1.1, R5.1
unnamed: Q2.1, R6.1
unnamed: U9.3 (GND), U9.29 (GND)
unnamed: R13.2, R14.1, U9.8 (VBUS)
unnamed: R15.1, U9.9 (~RST)
unnamed: R16.1, U9.11 (~SUSPEND)
O1: J14.1, U1.16 (O1)
O2: J15.1, U1.15 (O2)
O3: J16.1, U1.14 (O3)
O4: J17.1, U1.13 (O4)
O5: J10.1, U1.12 (O5)
O6: J11.1, U1.11 (O6)
O7: J12.1, U1.10 (O7)
RI: U9.2 (~RI/CLK)
RTS: Q1.2, R6.2, U9.24 (~RTS)
RXD: R8.1, U9.25 (RXD)
RXD0: R8.2
SENSOR_VN: U10.5 (SENSOR_VN)
SENSOR_VP: U10.4 (SENSOR_VP)
SERVO+: J3.P (POS), Servo1.2, Servo2.2, Servo3.2, Servo4.2, Servo5.2, Servo6.2, Servo7.2, Servo8.2
TR+: U1.9 (COMMON)
TXD: R7.2, U9.26 (TXD)
TXD0: R7.1
USB_DN: D4.1, J1.2 (D-), U9.5 (D-)
USB_DP: D2.1, J1.3 (D+), U9.4 (D+)
VBUS: D1.1, D3.A, J1.1 (VBUS), R13.1
VDD33: C1.1, C2.1, C3.1, C6.1, C9.1, C10.1, J5.9, J6.1, J7.1, J8.1, J9.1, R15.2, R17.1, U2.5 (Vio), U9.6 (VDD), U9.7 (VREGIN), U10.2 (VDD), U11.2 (VO)

Notes on the sheet:
CAN
真理値表 DTR RTS-->EN IO0 1 1 1 1 0 0 1 1 1 0 0 1 0 1 1 0
ESP32 DevKitC V4
サーボ
Micro USB 5V&USB-UART
24V電源
プッシュスイッチ
垂直MD
ソレノイドバルブ・表示灯
エンコーダ
ESP32モジュール

Board: 2 copper layers, 115.8 x 100.0 mm, 76 parts (0 on the bottom side), 50 nets.

Other parts of the board:
REF1, REF2, REF3, REF4: MountingHole_3.2mm_M3
