# Repository RRST-NHK-Project/kicad-ws

## KiCad design NUCLEO_F767ZI_MB/F767ZI_MB_V1.5/F767ZI_MB_V1.5.kicad_pcb

Board: 2 copper layers, 86.4 x 101.6 mm, 53 parts (4 on the bottom side), 53 nets.

Parts:
J1: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Vertical
J2: Conn_02x15_Odd_Even; PinHeader_2x15_P2.54mm_Vertical
J3: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical
J4: Conn_02x17_Odd_Even; PinHeader_2x17_P2.54mm_Vertical
J5, J6, J7: Conn_01x11_Pin; PinHeader_1x11_P2.54mm_Vertical
J8, J9, J10, J11: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J12, J17, J18, J19, J24, J25, J26, J27: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J13, J14, J15, J16, J20, J21, J22, J23: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J28, J29: XT60-M; AMASS_XT60-M_1x02_P7.20mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1, U2, U3, U4, U5, U6, U7, U8: IRLB3813PBF; PG-TO220-3_INF

Connections:
+5V: J1.9, J8.2, J9.2, J10.2, J11.2, R1.2, R2.1, R3.2, R4.1, R5.2, R6.1, R7.2, R8.1
GND: J1.11, J1.13, J2.12, J2.23, J4.5, J4.17, J4.22, J4.27, J5.1, J5.3, J6.1, J6.3, J7.1, J7.3, J8.4, J9.4, J10.4, J11.4, J12.3, J17.3, J18.3, J19.3, J24.3, J25.3, J26.3, J27.3, J28.N (NEG), J29.N (NEG), U1.3 (S), U2.3 (S), U3.3 (S), U4.3 (S), U5.3 (S), U6.3 (S), U7.3 (S), U8.3 (S)
unnamed: J13.2, U1.2 (D)
unnamed: J14.2, U2.2 (D)
unnamed: J15.2, U6.2 (D)
unnamed: J16.2, U3.2 (D)
unnamed: J20.2, U4.2 (D)
unnamed: J21.2, U5.2 (D)
unnamed: J22.2, U7.2 (D)
unnamed: J23.2, U8.2 (D)
unnamed: R9.2, U1.1 (G)
unnamed: R10.1, U2.1 (G)
unnamed: R11.2, U3.1 (G)
unnamed: R12.2, U4.1 (G)
unnamed: R13.2, U5.1 (G)
unnamed: R14.2, U6.1 (G)
unnamed: R15.2, U7.1 (G)
unnamed: R16.2, U8.1 (G)
PA_0: J4.29, J5.9
PA_3: J2.1, J5.5
PA_6: J3.12, J11.1, R7.1
PB_1: J4.7, J12.1
PB_6: J4.13, J17.1
PB_8: J3.2, J19.1
PB_10: J4.32, J26.1
PC_0: J2.3, J8.1, R1.1
PC_3: J2.5, J9.3, R4.2
PC_6: J3.1, J6.5
PC_7: J3.11, J6.9
PC_8: J1.2, J7.9
PC_9: J1.4, J7.5
PC_10: J1.6, J7.7
PC_11: J1.8, R12.1
PC_12: J1.10, R13.1
PD_2: J1.12, J5.11
PD_4: J2.8, J10.1, R5.1
PD_5: J2.6, J6.11
PD_6: J2.4, J6.7
PD_7: J2.2, J7.11
PD_13: J4.19, J18.1
PF_0: J2.21, R9.1
PF_1: J2.19, R10.2
PF_2: J2.17, J9.1, R3.1
PF_5: J2.9, J10.3, R6.2
PF_7: J2.26, J11.3, R8.2
PF_12: J3.20, R15.1
PF_13: J4.2, R16.1
PF_14: J4.8, R14.1
PF_15: J4.12, R11.1
PG_1: J2.30, J8.3, R2.2
PG_2: J1.14, J5.7
SERVO+: J12.2, J17.2, J18.2, J19.2, J24.2, J25.2, J26.2, J27.2, J28.P (POS)
TR+: J13.1, J14.1, J15.1, J16.1, J20.1, J21.1, J22.1, J23.1, J29.P (POS)

## KiCad design NUCLEO_F767ZI_MB/F767ZI_MB_V1.5alpha/F767ZI_MB_V1.5alpha.kicad_pcb

Parts:
ENC1: ENC1; PinHeader_1x04_P2.54mm_Vertical
ENC2: ENC2; PinHeader_1x04_P2.54mm_Vertical
ENC3: ENC3; PinHeader_1x04_P2.54mm_Vertical
ENC4: ENC4; PinHeader_1x04_P2.54mm_Vertical
J1: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Vertical
J2: Conn_02x15_Odd_Even; PinHeader_2x15_P2.54mm_Vertical
J3: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical
J4: Conn_02x17_Odd_Even; PinHeader_2x17_P2.54mm_Vertical
J5, J6: XT60-M; AMASS_XT60-M_1x02_P7.20mm_Vertical; PARTREV V1.2
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SV1: SV1; PinHeader_1x02_P2.54mm_Vertical
SV2: SV2; PinHeader_1x02_P2.54mm_Vertical
SV3: SV3; PinHeader_1x02_P2.54mm_Vertical
SV4: SV4; PinHeader_1x02_P2.54mm_Vertical
SV5: SV5; PinHeader_1x02_P2.54mm_Vertical
SV6: SV6; PinHeader_1x02_P2.54mm_Vertical
SV7: SV7; PinHeader_1x02_P2.54mm_Vertical
SV8: SV8; PinHeader_1x02_P2.54mm_Vertical
Servo1: Servo1; PinHeader_1x03_P2.54mm_Vertical
Servo2: Servo2; PinHeader_1x03_P2.54mm_Vertical
Servo3: Servo3; PinHeader_1x03_P2.54mm_Vertical
Servo4: Servo4; PinHeader_1x03_P2.54mm_Vertical
Servo5: Servo5; PinHeader_1x03_P2.54mm_Vertical
Servo6: Servo6; PinHeader_1x03_P2.54mm_Vertical
Servo7: Servo7; PinHeader_1x03_P2.54mm_Vertical
Servo8: Servo8; PinHeader_1x03_P2.54mm_Vertical
U1, U2, U3, U4, U5, U6, U7, U8: IRLB3813PBF; PG-TO220-3_INF
VMD1/VMD2: VMD1/VMD2; PinHeader_1x11_P2.54mm_Vertical
VMD3/VMD4: VMD3/VMD4; PinHeader_1x11_P2.54mm_Vertical
VMD5/VMD6: VMD5/VMD6; PinHeader_1x11_P2.54mm_Vertical

Connections:
+3.3V: J1.7
+5V: ENC1.2, ENC2.2, ENC3.2, ENC4.2, J1.9, R1.2, R2.1, R3.2, R4.1, R5.2, R6.1, R7.2, R8.1
GND: ENC1.4, ENC2.4, ENC3.4, ENC4.4, J1.11, J1.13, J2.12, J2.23, J4.5, J4.17, J4.22, J4.27, J5.N (NEG), J6.N (NEG), Servo1.3, Servo2.3, Servo3.3, Servo4.3, Servo5.3, Servo6.3, Servo7.3, Servo8.3, U1.3 (S), U2.3 (S), U3.3 (S), U4.3 (S), U5.3 (S), U6.3 (S), U7.3 (S), U8.3 (S), VMD1/VMD2.1, VMD1/VMD2.3, VMD3/VMD4.1, VMD3/VMD4.3, VMD5/VMD6.1, VMD5/VMD6.3
unnamed: SV1.2, U1.2 (D)
unnamed: SV2.2, U2.2 (D)
unnamed: SV3.2, U3.2 (D)
unnamed: SV4.2, U4.2 (D)
unnamed: SV5.2, U5.2 (D)
unnamed: SV6.2, U6.2 (D)
unnamed: SV7.2, U7.2 (D)
unnamed: SV8.2, U8.2 (D)
unnamed: R9.2, U1.1 (G)
unnamed: R10.2, U2.1 (G)
unnamed: R11.2, U3.1 (G)
unnamed: R13.2, U5.1 (G)
unnamed: R14.2, U6.1 (G)
unnamed: R15.2, U7.1 (G)
unnamed: R16.2, U8.1 (G)
PA_0: J4.29, VMD1/VMD2.9
PA_3: J2.1, VMD1/VMD2.5
PA_6: ENC4.1, J3.12, R7.1
PA_15: J3.9
PB_1: J4.7, Servo1.1
PB_3: J3.15
PB_6: J4.13, Servo2.1
PB_8: J3.2, Servo4.1
PB_9: J3.4
PB_10: J4.32, Servo7.1
PB_11: J4.34
PB_13: J3.5
PB_15: J3.3
PC_0: ENC1.1, J2.3, R1.1
PC_3: ENC2.3, J2.5, R4.2
PC_6: J3.1, VMD3/VMD4.5
PC_7: J3.11, VMD3/VMD4.9
PC_8: J1.2, VMD5/VMD6.9
PC_9: J1.4, VMD5/VMD6.5
PC_10: J1.6, VMD5/VMD6.7
PC_11: J1.8, R12.1
PC_12: J1.10, R13.1
PD_0: J2.25
PD_1: J2.27
PD_2: J1.12, VMD1/VMD2.11
PD_3: J2.10
PD_4: ENC3.1, J2.8, R5.1
PD_5: J2.6, VMD3/VMD4.11
PD_6: J2.4, VMD3/VMD4.7
PD_7: J2.2, VMD5/VMD6.11
PD_11: J4.23
PD_12: J4.21
PD_13: J4.19, Servo3.1
PE_2: J2.14
PE_3: J2.22
PE_4: J2.16
PE_5: J2.18, Servo8.1
PE_7: J4.20
PE_8: J4.18
PE_11: J4.6, Servo5.1
PE_14: J4.28, Servo6.1
PF_0: J2.21, R9.1
PF_1: J2.19, R10.1
PF_2: ENC2.1, J2.17, R3.1
PF_3: J2.7
PF_5: ENC3.3, J2.9, R6.2
PF_7: ENC4.3, J2.26, R8.2
PF_9: J2.28
PF_10: J2.11
PF_12: J3.20, R15.1
PF_13: J4.2, R16.1
PF_14: J4.8, R14.1
PF_15: J4.12, R11.1
PG_1: ENC1.3, J2.30, R2.2
PG_2: J1.14, VMD1/VMD2.7
PG_3: J1.16
PG_9: J4.16
PG_14: J4.14
SERVO+: J5.P (POS), Servo1.2, Servo2.2, Servo3.2, Servo4.2, Servo5.2, Servo6.2, Servo7.2, Servo8.2
TR+: J6.P (POS), SV1.1, SV2.1, SV3.1, SV4.1, SV5.1, SV6.1, SV7.1, SV8.1
VIN: J1.15

Board: 2 copper layers, 83.8 x 99.1 mm, 53 parts (4 on the bottom side), 55 nets.

## KiCad design NUCLEO_F767ZI_MB/sasakicatchrobomain25/sasakicatchrobomain25.kicad_pcb

Board: 2 copper layers, 116.0 x 96.6 mm, 31 parts (4 on the bottom side), 35 nets.

Parts:
3.3V_OUT1: 3.3V_OUT; PinSocket_2x06_P2.54mm_Vertical
5V_OUT1: 5V_OUT; PinSocket_2x06_P2.54mm_Vertical
CAN3.3V1: CAN3.3V; PinSocket_1x04_P2.54mm_Vertical
CAN5V1: CAN5V; PinSocket_1x04_P2.54mm_Vertical
ENC1: ENC1; PinHeader_1x04_P2.54mm_Vertical
ENC2: ENC2; PinHeader_1x04_P2.54mm_Vertical
ENC3: ENC3; PinHeader_1x04_P2.54mm_Vertical
ENC4: ENC4; PinHeader_1x04_P2.54mm_Vertical
J3: XT60-M; AMASS_XT60-M_1x02_P7.20mm_Vertical
J4: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Vertical
J6: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical
J7: Conn_02x17_Odd_Even; PinHeader_2x17_P2.54mm_Vertical
J8: Conn_02x15_Odd_Even; PinHeader_2x15_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Servo1: Servo1; PinHeader_1x03_P2.54mm_Vertical
Servo2: Servo2; PinHeader_1x03_P2.54mm_Vertical
Servo3: Servo3; PinHeader_1x03_P2.54mm_Vertical
Servo4: Servo4; PinHeader_1x03_P2.54mm_Vertical
Servo5: Servo5; PinHeader_1x03_P2.54mm_Vertical
Servo6: Servo6; PinHeader_1x03_P2.54mm_Vertical
VMD1/VMD2: VMD1/VMD2; PinHeader_1x11_P2.54mm_Vertical
VMD3/VMD4: VMD3/VMD4; PinHeader_1x11_P2.54mm_Vertical
VMD5/VMD6: VMD5/VMD6; PinHeader_1x11_P2.54mm_Vertical
VMD7/VMD8: VMD7/VMD8; PinHeader_1x11_P2.54mm_Vertical

Connections:
+3.3V: 3.3V_OUT1.1, 3.3V_OUT1.3, 3.3V_OUT1.5, 3.3V_OUT1.7, 3.3V_OUT1.9, 3.3V_OUT1.11, CAN3.3V1.1, J4.7
+5V: 5V_OUT1.1, 5V_OUT1.3, 5V_OUT1.5, 5V_OUT1.7, 5V_OUT1.9, 5V_OUT1.11, CAN5V1.1, ENC1.2, ENC2.2, ENC3.2, ENC4.2, J4.9, R1.2, R2.1, R3.2, R4.1, R5.2, R6.1, R7.2, R8.1
GND: 3.3V_OUT1.2, 3.3V_OUT1.4, 3.3V_OUT1.6, 3.3V_OUT1.8, 3.3V_OUT1.10, 3.3V_OUT1.12, 5V_OUT1.2, 5V_OUT1.4, 5V_OUT1.6, 5V_OUT1.8, 5V_OUT1.10, 5V_OUT1.12, CAN3.3V1.2, CAN5V1.2, ENC1.4, ENC2.4, ENC3.4, ENC4.4, J3.N (NEG), J4.11, J4.13, J7.5, J7.17, J7.22, J7.27, J8.12, J8.23, Servo1.3, Servo2.3, Servo3.3, Servo4.3, Servo5.3, Servo6.3, VMD1/VMD2.1, VMD1/VMD2.3, VMD3/VMD4.1, VMD3/VMD4.3, VMD5/VMD6.1, VMD5/VMD6.3, VMD7/VMD8.1, VMD7/VMD8.3
PA_0: J7.29, VMD1/VMD2.9
PA_3: J8.1, VMD1/VMD2.5
PA_6: ENC4.1, J6.12, R7.1
PB_1: J7.7, Servo1.1
PB_6: J7.13, Servo2.1
PB_8: J6.2, Servo4.1
PB_10: J7.32, VMD7/VMD8.9
PC_0: ENC1.1, J8.3, R1.1
PC_3: ENC2.3, J8.5, R4.2
PC_6: J6.1, VMD3/VMD4.5
PC_7: J6.11, VMD3/VMD4.9
PC_8: J4.2, VMD5/VMD6.9
PC_9: J4.4, VMD5/VMD6.5
PC_10: J4.6, VMD5/VMD6.7
PD_0: CAN3.3V1.3, CAN5V1.3, J8.25
PD_1: CAN3.3V1.4, CAN5V1.4, J8.27
PD_2: J4.12, VMD1/VMD2.11
PD_3: J8.10, VMD7/VMD8.11
PD_4: ENC3.1, J8.8, R5.1, VMD7/VMD8.7
PD_5: J8.6, VMD3/VMD4.11
PD_6: J8.4, VMD3/VMD4.7
PD_7: J8.2, VMD5/VMD6.11
PD_13: J7.19, Servo3.1
PE_5: J8.18, VMD7/VMD8.5
PE_7: J7.20, J8.26
PE_11: J7.6, Servo5.1
PF_2: ENC2.1, J8.17, R3.1
PF_5: ENC3.3, J8.9, R6.2
PF_7: ENC4.3, R8.2
PG_1: ENC1.3, J8.30, R2.2
PG_2: J4.14, VMD1/VMD2.7
SERVO+: J3.P (POS), Servo1.2, Servo2.2, Servo3.2, Servo4.2, Servo5.2, Servo6.2

## KiCad design RRST-ESP32-S3-Rev.1/RRST-ESP32-S3-Rev.1.kicad_pcb

Parts:
C1, C4, C5: 10uF; C_0603_1608Metric
C2, C3, C6, C7, C8: 100nF; C_0603_1608Metric
C9: 1uF; C_0603_1608Metric
D1, D3, D4: LED; LED_0603_1608Metric
D2: SS14; D_SMA
D5, D6, D8: LESD5D5.0CT1G; D_SOD-523; PARTREV O
J1, J3: Conn_01x22_Pin; PinHeader_1x22_P2.54mm_Vertical
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_XKB_U262-16XN-4BVC11
R1, R2: 5.1k; R_0603_1608Metric
R3, R4: 5.1K; R_0402_1005Metric
R5: 10k; R_0603_1608Metric
R6: 330; R_0603_1608Metric
SW1, SW2: SW_Push; SW_SPST_TS-1088-xR020
U1: ESP32-S3-WROOM-1
U2: LD1117S33TR_SOT223; SOT-223-3_TabPin2

Connections:
3V3: C3.1, C4.1, C5.1, C6.1, D1.2 (A), J1.1, J1.2, R2.1, R5.1, U1.2 (3V3), U2.2 (VO)
+5V: C1.1, C2.1, D2.1 (K), J1.21, R1.1, U2.3 (VI)
DN: D6.1, J2.A7 (D-), J2.B7 (D-), J3.20, U1.13 (USB_D-)
DP: D8.1, J2.A6 (D+), J2.B6 (D+), J3.19, U1.14 (USB_D+)
EN: C7.1, C9.1, J1.3, R5.2, SW1.2, U1.3 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, D3.1 (K), D4.1 (K), D5.2, D6.2, D8.2, J1.22, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J3.1, J3.21, J3.22, R3.2, R4.2, SW1.1, SW2.1, U1.1 (GND), U1.40 (GND), U1.41 (GND), U2.1 (GND)
IO0: C8.1, J3.14, R6.2, SW2.2, U1.27 (IO0)
IO1: J3.4, U1.39 (IO1)
IO2: J3.5, U1.38 (IO2)
IO3: J1.13, U1.15 (IO3)
IO4: J1.4, U1.4 (IO4)
IO5: J1.5, U1.5 (IO5)
IO6: J1.6, U1.6 (IO6)
IO7: J1.7, U1.7 (IO7)
IO8: J1.12, U1.12 (IO8)
IO9: J1.15, U1.17 (IO9)
IO10: J1.16, U1.18 (IO10)
IO11: J1.17, U1.19 (IO11)
IO12: J1.18, U1.20 (IO12)
IO13: J1.19, U1.21 (IO13)
IO14: J1.20, U1.22 (IO14)
IO15: J1.8, U1.8 (IO15)
IO16: J1.9, U1.9 (IO16)
IO17: J1.10, U1.10 (IO17)
IO18: J1.11, U1.11 (IO18)
IO21: J3.18, U1.23 (IO21)
IO35: J3.13, U1.28 (IO35)
IO36: J3.12, U1.29 (IO36)
IO37: J3.11, U1.30 (IO37)
IO38: J3.10, U1.31 (IO38)
IO39: J3.9, U1.32 (IO39)
IO40: J3.8, U1.33 (IO40)
IO41: J3.7, U1.34 (IO41)
IO42: J3.6, U1.35 (IO42)
IO45: J3.15, U1.26 (IO45)
IO46: J1.14, U1.16 (IO46)
IO47: J3.17, U1.24 (IO47)
IO48: J3.16, U1.25 (IO48)
unnamed: D1.1 (K), R6.1
unnamed: D3.2 (A), R1.2
unnamed: D4.2 (A), R2.2
unnamed: J2.A5 (CC1), R4.1
unnamed: J2.B5 (CC2), R3.1
RXD0: J3.3, U1.36 (RXD0)
TXD0: J3.2, U1.37 (TXD0)
VBUS: D2.2 (A), D5.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)

Notes on the sheet:
ESD保護

Board: 2 copper layers, 25.4 x 62.7 mm, 29 parts (2 on the bottom side), 46 nets.

File RRST-ESP32-S3-Rev.1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C4, C5",0603,3,10uF,
"C2, C3, C6, C7, C8",0603,5,100nF,
C9,0603,1,1uF,
"D1, D3, D4",0603,3,LED,
D2,D_SMA,1,SS14,
"D5, D6, D8",D_SOD-523,3,LESD5D5.0CT1G,
"J1, J3",PinHeader_1x22_P2.54mm_Vertical,2,Conn_01x22_Pin,
J2,USB_C_Receptacle_XKB_U262-16XN-4BVC11,1,USB_C_Receptacle_USB2.0_16P,
"R1, R2",0603,2,5.1k,
"R3, R4",0402,2,5.1K,
R5,0603,1,10k,
R6,0603,1,330,
"SW1, SW2",SW_SPST_TS-1088-xR020,2,SW_Push,
U1,ESP32-S3-WROOM-1,1,ESP32-S3-WROOM-1,
U2,SOT-223-3_TabPin2,1,LD1117S33TR_SOT223,
